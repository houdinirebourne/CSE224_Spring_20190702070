* NGSPICE file created from top.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_2 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_4 abstract view
.subckt sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s4s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
.ends

.subckt top A1[0] A1[1] A1[2] A1[3] A1[4] A2[0] A2[1] A2[2] A2[3] A2[4] A3[0] A3[1]
+ A3[2] A3[3] A3[4] ALUOp[0] ALUOp[1] ALUResult[0] ALUResult[10] ALUResult[11] ALUResult[12]
+ ALUResult[13] ALUResult[14] ALUResult[15] ALUResult[16] ALUResult[17] ALUResult[18]
+ ALUResult[19] ALUResult[1] ALUResult[20] ALUResult[21] ALUResult[22] ALUResult[23]
+ ALUResult[24] ALUResult[25] ALUResult[26] ALUResult[27] ALUResult[28] ALUResult[29]
+ ALUResult[2] ALUResult[30] ALUResult[31] ALUResult[3] ALUResult[4] ALUResult[5]
+ ALUResult[6] ALUResult[7] ALUResult[8] ALUResult[9] CLK VGND VPWR WD3[0] WD3[10]
+ WD3[11] WD3[12] WD3[13] WD3[14] WD3[15] WD3[16] WD3[17] WD3[18] WD3[19] WD3[1] WD3[20]
+ WD3[21] WD3[22] WD3[23] WD3[24] WD3[25] WD3[26] WD3[27] WD3[28] WD3[29] WD3[2] WD3[30]
+ WD3[31] WD3[3] WD3[4] WD3[5] WD3[6] WD3[7] WD3[8] WD3[9] WE3
XFILLER_0_118_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7963_ _3013_ net791 _3938_ VGND VGND VPWR VPWR _3948_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6914_ _3375_ VGND VGND VPWR VPWR _3376_ sky130_fd_sc_hd__buf_4
X_7894_ _3911_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6845_ _3005_ _3338_ VGND VGND VPWR VPWR _3339_ sky130_fd_sc_hd__nor2_2
XFILLER_0_18_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9564_ clknet_leaf_14_CLK _0724_ VGND VGND VPWR VPWR regfile.registers\[11\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6776_ _3153_ _3229_ VGND VGND VPWR VPWR _3302_ sky130_fd_sc_hd__nand2_4
X_9495_ clknet_leaf_36_CLK _0655_ VGND VGND VPWR VPWR regfile.registers\[16\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_5727_ _2062_ _2479_ VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__nor2_1
X_8515_ _4240_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_115_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8446_ _3003_ _3447_ VGND VGND VPWR VPWR _4204_ sky130_fd_sc_hd__nor2_2
X_5658_ _2410_ _2412_ _2097_ VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4609_ _1254_ _1364_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__nor2_1
X_5589_ _1799_ _2141_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__or2_1
X_8377_ _4167_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold340 regfile.registers\[18\]\[30\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
Xhold351 regfile.registers\[12\]\[16\] VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7328_ _3611_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
Xhold362 regfile.registers\[17\]\[18\] VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd3_1
Xhold384 regfile.registers\[8\]\[24\] VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__dlygate4sd3_1
X_7259_ net425 _3531_ _3564_ VGND VGND VPWR VPWR _3574_ sky130_fd_sc_hd__mux2_1
Xhold373 regfile.registers\[17\]\[15\] VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd3_1
Xhold395 regfile.registers\[0\]\[14\] VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1051 regfile.registers\[3\]\[21\] VGND VGND VPWR VPWR net1131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1040 regfile.registers\[14\]\[15\] VGND VGND VPWR VPWR net1120 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer7 _1399_ VGND VGND VPWR VPWR net1138 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_121_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_6_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_6_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_125_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4960_ _1655_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__buf_4
XFILLER_0_129_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4891_ regfile.registers\[28\]\[0\] regfile.registers\[29\]\[0\] regfile.registers\[30\]\[0\]
+ regfile.registers\[31\]\[0\] net1 net2 VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__mux4_1
XFILLER_0_129_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6630_ _3224_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6561_ _3186_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__clkbuf_1
X_8300_ _3009_ net618 _4119_ VGND VGND VPWR VPWR _4127_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5512_ regfile.registers\[0\]\[6\] regfile.registers\[1\]\[6\] regfile.registers\[2\]\[6\]
+ regfile.registers\[3\]\[6\] _1703_ _1706_ VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__mux4_1
XFILLER_0_120_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6492_ _3149_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_748 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9280_ clknet_leaf_76_CLK _0440_ VGND VGND VPWR VPWR regfile.registers\[25\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8231_ _4090_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__clkbuf_1
X_5443_ regfile.registers\[16\]\[10\] regfile.registers\[17\]\[10\] regfile.registers\[18\]\[10\]
+ regfile.registers\[19\]\[10\] _2050_ _2052_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8162_ net948 _3478_ _4047_ VGND VGND VPWR VPWR _4054_ sky130_fd_sc_hd__mux2_1
X_5374_ _2128_ _2129_ _2044_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__mux2_1
X_7113_ net218 _3482_ _3471_ VGND VGND VPWR VPWR _3483_ sky130_fd_sc_hd__mux2_1
X_4325_ _1079_ _1080_ _1040_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__mux2_1
X_8093_ _4017_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__clkbuf_1
X_7044_ _3444_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8995_ clknet_leaf_84_CLK _0155_ VGND VGND VPWR VPWR regfile.registers\[29\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_7946_ _3939_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7877_ net139 _3533_ _3902_ VGND VGND VPWR VPWR _3903_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6828_ _3073_ net968 _3325_ VGND VGND VPWR VPWR _3330_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6759_ _3293_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9547_ clknet_leaf_105_CLK _0707_ VGND VGND VPWR VPWR regfile.registers\[11\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_9478_ clknet_leaf_70_CLK _0638_ VGND VGND VPWR VPWR regfile.registers\[16\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_8429_ _4195_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_98_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold170 regfile.registers\[12\]\[25\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_103_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold192 regfile.registers\[29\]\[25\] VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold181 regfile.registers\[10\]\[28\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5090_ regfile.registers\[28\]\[17\] regfile.registers\[29\]\[17\] regfile.registers\[30\]\[17\]
+ regfile.registers\[31\]\[17\] _1689_ _1693_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5992_ _2347_ _2622_ VGND VGND VPWR VPWR _2732_ sky130_fd_sc_hd__nor2_1
X_7800_ net394 _3525_ _3855_ VGND VGND VPWR VPWR _3862_ sky130_fd_sc_hd__mux2_1
X_8780_ clknet_leaf_110_CLK _0964_ VGND VGND VPWR VPWR regfile.registers\[14\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4943_ _1696_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_35_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7731_ _3825_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7662_ net289 _3523_ _3783_ VGND VGND VPWR VPWR _3789_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9401_ clknet_leaf_37_CLK _0561_ VGND VGND VPWR VPWR regfile.registers\[24\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6613_ _3215_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__clkbuf_1
X_4874_ regfile.registers\[4\]\[18\] regfile.registers\[5\]\[18\] regfile.registers\[6\]\[18\]
+ regfile.registers\[7\]\[18\] _1173_ _1175_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7593_ _3752_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_15_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6544_ _3064_ net841 _3177_ VGND VGND VPWR VPWR _3178_ sky130_fd_sc_hd__mux2_1
X_9332_ clknet_leaf_22_CLK _0492_ VGND VGND VPWR VPWR regfile.registers\[21\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6475_ net30 VGND VGND VPWR VPWR _3139_ sky130_fd_sc_hd__buf_2
X_9263_ clknet_leaf_2_CLK _0423_ VGND VGND VPWR VPWR regfile.registers\[18\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8214_ _4081_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5426_ regfile.registers\[16\]\[11\] regfile.registers\[17\]\[11\] regfile.registers\[18\]\[11\]
+ regfile.registers\[19\]\[11\] _1675_ _1692_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9194_ clknet_leaf_104_CLK _0354_ VGND VGND VPWR VPWR regfile.registers\[30\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_5357_ _1702_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__clkbuf_8
X_8145_ net868 _3529_ _4036_ VGND VGND VPWR VPWR _4045_ sky130_fd_sc_hd__mux2_1
X_5288_ _1684_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__buf_4
X_4308_ _1062_ _1063_ _1035_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__mux2_1
X_8076_ _4008_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__clkbuf_1
X_7027_ net759 _3137_ _3434_ VGND VGND VPWR VPWR _3436_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8978_ clknet_leaf_60_CLK _0138_ VGND VGND VPWR VPWR regfile.registers\[7\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_7929_ _3930_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_108_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_109_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4590_ _1344_ _1345_ _1259_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_12_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold928 regfile.registers\[24\]\[28\] VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold917 regfile.registers\[31\]\[14\] VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__dlygate4sd3_1
Xhold906 regfile.registers\[26\]\[15\] VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6260_ _2984_ _2985_ VGND VGND VPWR VPWR _2986_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold939 regfile.registers\[29\]\[0\] VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__dlygate4sd3_1
X_6191_ _1996_ _2903_ _2919_ VGND VGND VPWR VPWR _2920_ sky130_fd_sc_hd__o21ba_1
X_5211_ regfile.registers\[24\]\[27\] regfile.registers\[25\]\[27\] regfile.registers\[26\]\[27\]
+ regfile.registers\[27\]\[27\] _1767_ _1768_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__mux4_1
XFILLER_0_86_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5142_ _1897_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__buf_4
X_5073_ _1824_ _1825_ _1826_ _1827_ _1713_ _1828_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__mux4_1
X_8901_ clknet_leaf_63_CLK _0061_ VGND VGND VPWR VPWR regfile.registers\[19\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_84_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8832_ clknet_leaf_73_CLK _1016_ VGND VGND VPWR VPWR regfile.registers\[5\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_32_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5975_ _2573_ _2591_ VGND VGND VPWR VPWR _2716_ sky130_fd_sc_hd__and2_1
X_8763_ clknet_leaf_38_CLK _0947_ VGND VGND VPWR VPWR regfile.registers\[8\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_4926_ regfile.registers\[20\]\[23\] regfile.registers\[21\]\[23\] regfile.registers\[22\]\[23\]
+ regfile.registers\[23\]\[23\] _1676_ _1681_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__mux4_1
X_8694_ clknet_leaf_53_CLK _0878_ VGND VGND VPWR VPWR regfile.registers\[0\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_7714_ _3816_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4857_ _1190_ _1612_ _1205_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__o21a_1
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7645_ net383 _3506_ _3772_ VGND VGND VPWR VPWR _3780_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7576_ _3743_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9315_ clknet_leaf_83_CLK _0475_ VGND VGND VPWR VPWR regfile.registers\[21\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_6527_ _3048_ net754 _3166_ VGND VGND VPWR VPWR _3169_ sky130_fd_sc_hd__mux2_1
X_4788_ regfile.registers\[16\]\[10\] regfile.registers\[17\]\[10\] regfile.registers\[18\]\[10\]
+ regfile.registers\[19\]\[10\] net86 _1043_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__mux4_1
XFILLER_0_120_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6458_ _3127_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9246_ clknet_leaf_71_CLK _0406_ VGND VGND VPWR VPWR regfile.registers\[18\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_6389_ _3079_ net884 _3065_ VGND VGND VPWR VPWR _3080_ sky130_fd_sc_hd__mux2_1
X_9177_ clknet_leaf_49_CLK _0337_ VGND VGND VPWR VPWR regfile.registers\[2\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_5409_ regfile.registers\[20\]\[12\] regfile.registers\[21\]\[12\] regfile.registers\[22\]\[12\]
+ regfile.registers\[23\]\[12\] _2113_ _2114_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__mux4_1
Xclkload90 clknet_leaf_82_CLK VGND VGND VPWR VPWR clkload90/Y sky130_fd_sc_hd__inv_8
XFILLER_0_30_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8128_ _4024_ VGND VGND VPWR VPWR _4036_ sky130_fd_sc_hd__clkbuf_8
X_8059_ _3999_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_50_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_104_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5760_ _2481_ _2484_ _2480_ VGND VGND VPWR VPWR _2512_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5691_ _2441_ _2444_ _2040_ VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__mux2_1
X_4711_ _1465_ _1466_ _1036_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__mux2_1
XFILLER_0_127_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7430_ _3666_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
X_4642_ _1392_ _1394_ _1397_ _1078_ _1057_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__a221o_1
XFILLER_0_44_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4573_ _1189_ _1328_ _1078_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__a21o_1
X_7361_ _3629_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold703 regfile.registers\[22\]\[6\] VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dlygate4sd3_1
Xhold725 regfile.registers\[14\]\[23\] VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold736 regfile.registers\[6\]\[19\] VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlygate4sd3_1
Xhold714 regfile.registers\[30\]\[15\] VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlygate4sd3_1
X_9100_ clknet_leaf_107_CLK _0260_ VGND VGND VPWR VPWR regfile.registers\[27\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_7292_ _3025_ net799 _3591_ VGND VGND VPWR VPWR _3593_ sky130_fd_sc_hd__mux2_1
X_6312_ _3027_ net1045 _3023_ VGND VGND VPWR VPWR _3028_ sky130_fd_sc_hd__mux2_1
Xhold758 regfile.registers\[15\]\[29\] VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlygate4sd3_1
X_6243_ _2420_ _2968_ _2501_ VGND VGND VPWR VPWR _2969_ sky130_fd_sc_hd__mux2_1
Xhold747 regfile.registers\[9\]\[31\] VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlygate4sd3_1
X_9031_ clknet_leaf_62_CLK _0191_ VGND VGND VPWR VPWR regfile.registers\[31\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold769 regfile.registers\[31\]\[13\] VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6174_ _1996_ _2903_ VGND VGND VPWR VPWR _2904_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_90_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5125_ _1720_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__buf_4
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5056_ regfile.registers\[8\]\[18\] regfile.registers\[9\]\[18\] regfile.registers\[10\]\[18\]
+ regfile.registers\[11\]\[18\] _1689_ _1693_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__mux4_1
X_8815_ clknet_leaf_7_CLK _0999_ VGND VGND VPWR VPWR regfile.registers\[6\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_5958_ _2104_ _2696_ _2700_ VGND VGND VPWR VPWR _2701_ sky130_fd_sc_hd__o21a_1
X_8746_ clknet_leaf_105_CLK _0930_ VGND VGND VPWR VPWR regfile.registers\[8\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_4909_ _1664_ _1060_ _1084_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__or3_1
XFILLER_0_63_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5889_ _2246_ net1145 _2634_ VGND VGND VPWR VPWR _2635_ sky130_fd_sc_hd__a21oi_2
X_8677_ clknet_leaf_64_CLK _0861_ VGND VGND VPWR VPWR regfile.registers\[0\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7628_ _3770_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
X_7559_ _3087_ net776 _3699_ VGND VGND VPWR VPWR _3734_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9229_ clknet_leaf_95_CLK _0389_ VGND VGND VPWR VPWR regfile.registers\[9\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold41 regfile.registers\[0\]\[24\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 regfile.registers\[11\]\[24\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 regfile.registers\[19\]\[4\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 regfile.registers\[11\]\[5\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold96 regfile.registers\[7\]\[22\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 regfile.registers\[6\]\[6\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_5 _1923_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer28 net111 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
Xrebuffer39 _1464_ VGND VGND VPWR VPWR net1148 sky130_fd_sc_hd__dlygate4sd1_1
X_6930_ _3384_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6861_ net314 _3107_ _3340_ VGND VGND VPWR VPWR _3348_ sky130_fd_sc_hd__mux2_1
X_5812_ _2559_ _2560_ VGND VGND VPWR VPWR _2561_ sky130_fd_sc_hd__or2b_1
X_8600_ clknet_leaf_21_CLK _0784_ VGND VGND VPWR VPWR regfile.registers\[23\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_9580_ clknet_leaf_110_CLK _0740_ VGND VGND VPWR VPWR regfile.registers\[10\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_6792_ _3037_ net706 _3303_ VGND VGND VPWR VPWR _3311_ sky130_fd_sc_hd__mux2_1
X_5743_ _2040_ _2335_ VGND VGND VPWR VPWR _2495_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8531_ net323 net46 _4244_ VGND VGND VPWR VPWR _4249_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5674_ _1168_ _2230_ VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__and2_1
X_8462_ net555 net45 _4205_ VGND VGND VPWR VPWR _4213_ sky130_fd_sc_hd__mux2_1
X_4625_ regfile.registers\[12\]\[24\] regfile.registers\[13\]\[24\] regfile.registers\[14\]\[24\]
+ regfile.registers\[15\]\[24\] _1351_ _1352_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_79_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7413_ _3656_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_20_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8393_ _4176_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4556_ regfile.registers\[0\]\[27\] regfile.registers\[1\]\[27\] regfile.registers\[2\]\[27\]
+ regfile.registers\[3\]\[27\] _1201_ _1203_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__mux4_1
X_7344_ _3077_ net1041 _3613_ VGND VGND VPWR VPWR _3620_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold511 regfile.registers\[25\]\[12\] VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__dlygate4sd3_1
Xhold500 regfile.registers\[9\]\[13\] VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_114_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold522 regfile.registers\[8\]\[8\] VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold544 regfile.registers\[29\]\[3\] VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__dlygate4sd3_1
Xhold533 regfile.registers\[13\]\[17\] VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__dlygate4sd3_1
X_4487_ regfile.registers\[28\]\[20\] regfile.registers\[29\]\[20\] regfile.registers\[30\]\[20\]
+ regfile.registers\[31\]\[20\] _1207_ _1208_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__mux4_1
Xhold588 regfile.registers\[13\]\[22\] VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlygate4sd3_1
X_7275_ _3582_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
Xhold566 regfile.registers\[22\]\[9\] VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__dlygate4sd3_1
Xhold577 regfile.registers\[19\]\[18\] VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold555 regfile.registers\[17\]\[6\] VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__dlygate4sd3_1
X_9014_ clknet_leaf_51_CLK _0174_ VGND VGND VPWR VPWR regfile.registers\[29\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_6226_ _2951_ _2952_ VGND VGND VPWR VPWR _2953_ sky130_fd_sc_hd__or2b_1
Xhold599 regfile.registers\[23\]\[8\] VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6157_ _1447_ _1384_ _2871_ _2741_ VGND VGND VPWR VPWR _2888_ sky130_fd_sc_hd__a31o_1
XFILLER_0_110_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5108_ regfile.registers\[20\]\[16\] regfile.registers\[21\]\[16\] regfile.registers\[22\]\[16\]
+ regfile.registers\[23\]\[16\] _1705_ _1708_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__mux4_1
X_6088_ _2040_ _2797_ VGND VGND VPWR VPWR _2823_ sky130_fd_sc_hd__nor2_1
X_5039_ regfile.registers\[0\]\[20\] regfile.registers\[1\]\[20\] regfile.registers\[2\]\[20\]
+ regfile.registers\[3\]\[20\] _1719_ _1722_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8729_ clknet_leaf_38_CLK _0913_ VGND VGND VPWR VPWR regfile.registers\[15\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput64 net64 VGND VGND VPWR VPWR ALUResult[23] sky130_fd_sc_hd__clkbuf_4
Xoutput53 net53 VGND VGND VPWR VPWR ALUResult[13] sky130_fd_sc_hd__buf_2
Xoutput75 net75 VGND VGND VPWR VPWR ALUResult[4] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_112_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4410_ _1057_ _1153_ _1157_ _1161_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__a32o_2
XFILLER_0_112_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5390_ regfile.registers\[16\]\[13\] regfile.registers\[17\]\[13\] regfile.registers\[18\]\[13\]
+ regfile.registers\[19\]\[13\] _1673_ _1690_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__mux4_1
X_4341_ _1095_ _1096_ _1040_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7060_ net143 _3101_ _3449_ VGND VGND VPWR VPWR _3454_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4272_ A2[1] VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6011_ _2730_ _2740_ _2750_ _2621_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__o22a_2
XFILLER_0_118_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7962_ _3947_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_6_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6913_ _3091_ _3338_ VGND VGND VPWR VPWR _3375_ sky130_fd_sc_hd__nor2_2
X_7893_ net253 _3482_ _3902_ VGND VGND VPWR VPWR _3911_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6844_ net13 net12 net11 VGND VGND VPWR VPWR _3338_ sky130_fd_sc_hd__or3b_2
XFILLER_0_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9563_ clknet_leaf_39_CLK _0723_ VGND VGND VPWR VPWR regfile.registers\[11\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6775_ _3301_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9494_ clknet_leaf_53_CLK _0654_ VGND VGND VPWR VPWR regfile.registers\[16\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_5726_ _2039_ _2478_ VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8514_ net370 net16 _3007_ VGND VGND VPWR VPWR _4240_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8445_ _4203_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5657_ _1166_ _2411_ _1145_ VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__o21ai_1
X_4608_ _1362_ _1363_ _1190_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__mux2_1
X_5588_ _2341_ _2342_ VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__and2b_1
X_8376_ net1117 _3488_ _4132_ VGND VGND VPWR VPWR _4167_ sky130_fd_sc_hd__mux2_1
X_4539_ regfile.registers\[12\]\[26\] regfile.registers\[13\]\[26\] regfile.registers\[14\]\[26\]
+ regfile.registers\[15\]\[26\] _1172_ _1279_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__mux4_1
Xhold352 regfile.registers\[8\]\[20\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__dlygate4sd3_1
Xhold341 regfile.registers\[16\]\[13\] VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold330 regfile.registers\[9\]\[3\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
X_7327_ _3060_ net486 _3602_ VGND VGND VPWR VPWR _3611_ sky130_fd_sc_hd__mux2_1
Xhold374 regfile.registers\[5\]\[23\] VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__dlygate4sd3_1
Xhold385 regfile.registers\[2\]\[31\] VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__dlygate4sd3_1
X_7258_ _3573_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
Xhold396 regfile.registers\[18\]\[7\] VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold363 regfile.registers\[20\]\[3\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6209_ _2875_ _2892_ VGND VGND VPWR VPWR _2937_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7189_ net223 _3533_ _3534_ VGND VGND VPWR VPWR _3535_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1030 regfile.registers\[23\]\[10\] VGND VGND VPWR VPWR net1110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1041 regfile.registers\[25\]\[0\] VGND VGND VPWR VPWR net1121 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1052 regfile.registers\[26\]\[21\] VGND VGND VPWR VPWR net1132 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_52_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer8 _1256_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_114_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4890_ _1643_ _1644_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6560_ _3081_ net959 _3177_ VGND VGND VPWR VPWR _3186_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5511_ regfile.registers\[4\]\[6\] regfile.registers\[5\]\[6\] regfile.registers\[6\]\[6\]
+ regfile.registers\[7\]\[6\] _1703_ _1706_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__mux4_1
XFILLER_0_124_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6491_ net665 _3011_ _3135_ VGND VGND VPWR VPWR _3149_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8230_ net876 _3478_ _4083_ VGND VGND VPWR VPWR _4090_ sky130_fd_sc_hd__mux2_1
X_5442_ regfile.registers\[20\]\[10\] regfile.registers\[21\]\[10\] regfile.registers\[22\]\[10\]
+ regfile.registers\[23\]\[10\] _2050_ _2052_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8161_ _4053_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__clkbuf_1
X_5373_ regfile.registers\[24\]\[14\] regfile.registers\[25\]\[14\] regfile.registers\[26\]\[14\]
+ regfile.registers\[27\]\[14\] _1674_ _1691_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__mux4_1
X_8092_ net727 _3544_ _4011_ VGND VGND VPWR VPWR _4017_ sky130_fd_sc_hd__mux2_1
X_7112_ net36 VGND VGND VPWR VPWR _3482_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4324_ regfile.registers\[0\]\[5\] regfile.registers\[1\]\[5\] regfile.registers\[2\]\[5\]
+ regfile.registers\[3\]\[5\] net96 _1044_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__mux4_1
X_7043_ net704 _3013_ _3434_ VGND VGND VPWR VPWR _3444_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8994_ clknet_leaf_86_CLK _0154_ VGND VGND VPWR VPWR regfile.registers\[29\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7945_ _3134_ net385 _3938_ VGND VGND VPWR VPWR _3939_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7876_ _3879_ VGND VGND VPWR VPWR _3902_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_38_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6827_ _3329_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9546_ clknet_leaf_106_CLK _0706_ VGND VGND VPWR VPWR regfile.registers\[11\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_6758_ net860 _3141_ _3289_ VGND VGND VPWR VPWR _3293_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5709_ _2460_ _2461_ _2252_ VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__mux2_1
X_6689_ _3256_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__clkbuf_1
X_9477_ clknet_leaf_63_CLK _0637_ VGND VGND VPWR VPWR regfile.registers\[16\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_8428_ net824 _3540_ _4191_ VGND VGND VPWR VPWR _4195_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8359_ _4158_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__clkbuf_1
Xhold160 regfile.registers\[4\]\[15\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold171 regfile.registers\[5\]\[13\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 regfile.registers\[2\]\[1\] VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 regfile.registers\[2\]\[16\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_78_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_87_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5991_ _1111_ _2335_ VGND VGND VPWR VPWR _2731_ sky130_fd_sc_hd__nor2_2
X_4942_ _1687_ _1695_ _1697_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__mux2_1
X_7730_ _3054_ net794 _3819_ VGND VGND VPWR VPWR _3825_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_96_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7661_ _3788_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9400_ clknet_leaf_23_CLK _0560_ VGND VGND VPWR VPWR regfile.registers\[24\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6612_ net175 _3132_ _3205_ VGND VGND VPWR VPWR _3215_ sky130_fd_sc_hd__mux2_1
X_4873_ _1214_ _1628_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7592_ _3052_ net863 _3747_ VGND VGND VPWR VPWR _3752_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9331_ clknet_leaf_28_CLK _0491_ VGND VGND VPWR VPWR regfile.registers\[21\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_6543_ _3154_ VGND VGND VPWR VPWR _3177_ sky130_fd_sc_hd__buf_6
X_6474_ _3138_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9262_ clknet_leaf_4_CLK _0422_ VGND VGND VPWR VPWR regfile.registers\[18\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8213_ net660 _3529_ _4072_ VGND VGND VPWR VPWR _4081_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5425_ regfile.registers\[28\]\[11\] regfile.registers\[29\]\[11\] regfile.registers\[30\]\[11\]
+ regfile.registers\[31\]\[11\] _1675_ _1692_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9193_ clknet_leaf_103_CLK _0353_ VGND VGND VPWR VPWR regfile.registers\[30\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8144_ _4044_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__clkbuf_1
X_5356_ _1712_ _2111_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__or2_1
X_5287_ regfile.registers\[16\]\[3\] regfile.registers\[17\]\[3\] regfile.registers\[18\]\[3\]
+ regfile.registers\[19\]\[3\] _1674_ _1691_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__mux4_1
X_4307_ regfile.registers\[16\]\[5\] regfile.registers\[17\]\[5\] regfile.registers\[18\]\[5\]
+ regfile.registers\[19\]\[5\] _1026_ _1061_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__mux4_1
X_8075_ net675 _3527_ _4000_ VGND VGND VPWR VPWR _4008_ sky130_fd_sc_hd__mux2_1
X_7026_ _3435_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8977_ clknet_leaf_6_CLK _0137_ VGND VGND VPWR VPWR regfile.registers\[7\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7928_ _3118_ net591 _3927_ VGND VGND VPWR VPWR _3930_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7859_ _3893_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9529_ clknet_leaf_38_CLK _0689_ VGND VGND VPWR VPWR regfile.registers\[12\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold918 regfile.registers\[20\]\[18\] VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__dlygate4sd3_1
Xhold907 regfile.registers\[10\]\[18\] VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__dlygate4sd3_1
X_5210_ regfile.registers\[28\]\[27\] regfile.registers\[29\]\[27\] regfile.registers\[30\]\[27\]
+ regfile.registers\[31\]\[27\] _1767_ _1768_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__mux4_1
XFILLER_0_110_724 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold929 regfile.registers\[19\]\[13\] VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__dlygate4sd3_1
X_6190_ _2875_ _2885_ _2892_ _2904_ _2890_ VGND VGND VPWR VPWR _2919_ sky130_fd_sc_hd__o311a_1
XFILLER_0_110_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5141_ _1693_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__clkbuf_4
X_5072_ _1716_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8900_ clknet_leaf_92_CLK _0060_ VGND VGND VPWR VPWR regfile.registers\[19\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_126_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8831_ clknet_leaf_74_CLK _1015_ VGND VGND VPWR VPWR regfile.registers\[5\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_126_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8762_ clknet_leaf_32_CLK _0946_ VGND VGND VPWR VPWR regfile.registers\[8\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_5974_ _2709_ _2707_ _2715_ _2621_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__o22a_1
X_7713_ _3037_ net621 _3808_ VGND VGND VPWR VPWR _3816_ sky130_fd_sc_hd__mux2_1
X_8693_ clknet_leaf_39_CLK _0877_ VGND VGND VPWR VPWR regfile.registers\[0\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_4925_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4856_ regfile.registers\[0\]\[19\] regfile.registers\[1\]\[19\] regfile.registers\[2\]\[19\]
+ regfile.registers\[3\]\[19\] _1207_ _1208_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__mux4_1
X_7644_ _3779_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7575_ _3035_ net991 _3736_ VGND VGND VPWR VPWR _3743_ sky130_fd_sc_hd__mux2_1
X_4787_ regfile.registers\[20\]\[10\] regfile.registers\[21\]\[10\] regfile.registers\[22\]\[10\]
+ regfile.registers\[23\]\[10\] net86 _1043_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__mux4_1
X_9314_ clknet_leaf_85_CLK _0474_ VGND VGND VPWR VPWR regfile.registers\[21\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_6526_ _3168_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_95_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9245_ clknet_leaf_13_CLK _0405_ VGND VGND VPWR VPWR regfile.registers\[9\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6457_ net760 _3126_ _3114_ VGND VGND VPWR VPWR _3127_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload80 clknet_leaf_71_CLK VGND VGND VPWR VPWR clkload80/Y sky130_fd_sc_hd__inv_6
X_6388_ net35 VGND VGND VPWR VPWR _3079_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_101_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9176_ clknet_leaf_17_CLK _0336_ VGND VGND VPWR VPWR regfile.registers\[2\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_5408_ regfile.registers\[16\]\[12\] regfile.registers\[17\]\[12\] regfile.registers\[18\]\[12\]
+ regfile.registers\[19\]\[12\] _2113_ _2114_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__mux4_1
Xclkload91 clknet_leaf_90_CLK VGND VGND VPWR VPWR clkload91/Y sky130_fd_sc_hd__bufinv_16
X_8127_ _4035_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__clkbuf_1
X_5339_ _2093_ _2094_ net3 VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__mux2_1
X_8058_ net902 _3510_ _3989_ VGND VGND VPWR VPWR _3999_ sky130_fd_sc_hd__mux2_1
X_7009_ _3426_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5690_ _2442_ _2443_ _2252_ VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__mux2_2
X_4710_ regfile.registers\[16\]\[13\] regfile.registers\[17\]\[13\] regfile.registers\[18\]\[13\]
+ regfile.registers\[19\]\[13\] net1147 _1029_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux4_1
XFILLER_0_127_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4641_ _1395_ _1396_ _1040_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4572_ regfile.registers\[12\]\[31\] regfile.registers\[13\]\[31\] regfile.registers\[14\]\[31\]
+ regfile.registers\[15\]\[31\] _1324_ _1325_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__mux4_1
X_7360_ _3025_ net1084 _3627_ VGND VGND VPWR VPWR _3629_ sky130_fd_sc_hd__mux2_1
Xhold726 regfile.registers\[31\]\[23\] VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlygate4sd3_1
Xhold715 regfile.registers\[2\]\[26\] VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlygate4sd3_1
Xhold737 regfile.registers\[19\]\[1\] VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dlygate4sd3_1
X_6311_ net38 VGND VGND VPWR VPWR _3027_ sky130_fd_sc_hd__clkbuf_2
Xhold704 regfile.registers\[6\]\[1\] VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7291_ _3592_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
X_6242_ _2498_ _2967_ _2327_ VGND VGND VPWR VPWR _2968_ sky130_fd_sc_hd__mux2_1
Xhold748 regfile.registers\[16\]\[15\] VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlygate4sd3_1
X_9030_ clknet_leaf_69_CLK _0190_ VGND VGND VPWR VPWR regfile.registers\[31\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold759 regfile.registers\[15\]\[3\] VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6173_ _1298_ _2902_ VGND VGND VPWR VPWR _2903_ sky130_fd_sc_hd__xnor2_2
X_5124_ _1804_ _1878_ _1879_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_90_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5055_ _1807_ _1810_ _1697_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8814_ clknet_leaf_5_CLK _0998_ VGND VGND VPWR VPWR regfile.registers\[6\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5957_ _2104_ _2699_ VGND VGND VPWR VPWR _2700_ sky130_fd_sc_hd__nand2_1
X_8745_ clknet_leaf_100_CLK _0929_ VGND VGND VPWR VPWR regfile.registers\[8\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4908_ net14 VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__inv_2
X_8676_ clknet_leaf_65_CLK _0860_ VGND VGND VPWR VPWR regfile.registers\[0\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5888_ _2229_ _2597_ _2616_ _2246_ VGND VGND VPWR VPWR _2634_ sky130_fd_sc_hd__o22a_1
XFILLER_0_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7627_ _3087_ net1099 _3735_ VGND VGND VPWR VPWR _3770_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4839_ _1593_ _1594_ _1287_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__mux2_1
XFILLER_0_105_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7558_ _3733_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7489_ _3085_ net821 _3663_ VGND VGND VPWR VPWR _3697_ sky130_fd_sc_hd__mux2_1
X_6509_ _3159_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9228_ clknet_leaf_1_CLK _0388_ VGND VGND VPWR VPWR regfile.registers\[9\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_9159_ clknet_leaf_59_CLK _0319_ VGND VGND VPWR VPWR regfile.registers\[2\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold53 regfile.registers\[1\]\[24\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 regfile.registers\[4\]\[20\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 regfile.registers\[5\]\[6\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 regfile.registers\[20\]\[23\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 regfile.registers\[9\]\[25\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 regfile.registers\[9\]\[22\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_6 _1190_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer29 net1143 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_2
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6860_ _3347_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__clkbuf_1
X_5811_ _2286_ _2558_ VGND VGND VPWR VPWR _2560_ sky130_fd_sc_hd__or2_1
X_6791_ _3310_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5742_ _2105_ _2491_ _2493_ VGND VGND VPWR VPWR _2494_ sky130_fd_sc_hd__o21a_1
XFILLER_0_9_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8530_ _4248_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__clkbuf_1
X_5673_ _2424_ _2425_ _2426_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8461_ _4212_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4624_ regfile.registers\[8\]\[24\] regfile.registers\[9\]\[24\] regfile.registers\[10\]\[24\]
+ regfile.registers\[11\]\[24\] _1351_ _1352_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_79_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7412_ _3077_ net1034 _3649_ VGND VGND VPWR VPWR _3656_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8392_ net1002 _3504_ _4169_ VGND VGND VPWR VPWR _4176_ sky130_fd_sc_hd__mux2_1
X_7343_ _3619_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
X_4555_ regfile.registers\[4\]\[27\] regfile.registers\[5\]\[27\] regfile.registers\[6\]\[27\]
+ regfile.registers\[7\]\[27\] _1201_ _1203_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__mux4_1
Xhold501 regfile.registers\[20\]\[8\] VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold534 regfile.registers\[30\]\[24\] VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__dlygate4sd3_1
Xhold523 regfile.registers\[20\]\[27\] VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__dlygate4sd3_1
Xhold545 regfile.registers\[16\]\[27\] VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold512 regfile.registers\[25\]\[31\] VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__dlygate4sd3_1
X_9013_ clknet_leaf_29_CLK _0173_ VGND VGND VPWR VPWR regfile.registers\[29\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold578 regfile.registers\[30\]\[23\] VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dlygate4sd3_1
X_4486_ _1240_ _1241_ _1211_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__mux2_1
Xhold567 regfile.registers\[20\]\[28\] VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__dlygate4sd3_1
X_7274_ net632 _3478_ _3575_ VGND VGND VPWR VPWR _3582_ sky130_fd_sc_hd__mux2_1
Xhold556 regfile.registers\[15\]\[6\] VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__dlygate4sd3_1
X_6225_ _1942_ _2950_ VGND VGND VPWR VPWR _2952_ sky130_fd_sc_hd__or2_1
Xhold589 regfile.registers\[18\]\[4\] VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlygate4sd3_1
X_6156_ _2875_ _2885_ VGND VGND VPWR VPWR _2887_ sky130_fd_sc_hd__or2_1
X_5107_ regfile.registers\[16\]\[16\] regfile.registers\[17\]\[16\] regfile.registers\[18\]\[16\]
+ regfile.registers\[19\]\[16\] _1705_ _1708_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__mux4_1
X_6087_ _2753_ _2821_ _1126_ VGND VGND VPWR VPWR _2822_ sky130_fd_sc_hd__mux2_1
X_5038_ regfile.registers\[4\]\[20\] regfile.registers\[5\]\[20\] regfile.registers\[6\]\[20\]
+ regfile.registers\[7\]\[20\] _1719_ _1722_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__mux4_1
XFILLER_0_94_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8728_ clknet_leaf_17_CLK _0912_ VGND VGND VPWR VPWR regfile.registers\[15\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_6989_ net715 _3099_ _3412_ VGND VGND VPWR VPWR _3416_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_101_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8659_ clknet_leaf_27_CLK _0843_ VGND VGND VPWR VPWR regfile.registers\[22\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput65 net65 VGND VGND VPWR VPWR ALUResult[24] sky130_fd_sc_hd__clkbuf_4
Xoutput54 net54 VGND VGND VPWR VPWR ALUResult[14] sky130_fd_sc_hd__buf_6
Xoutput76 net76 VGND VGND VPWR VPWR ALUResult[5] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_112_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_103_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_103_CLK
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_8_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4340_ regfile.registers\[24\]\[3\] regfile.registers\[25\]\[3\] regfile.registers\[26\]\[3\]
+ regfile.registers\[27\]\[3\] _1089_ _1090_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__mux4_1
XFILLER_0_22_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4271_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__buf_12
XFILLER_0_120_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6010_ _2744_ _2749_ VGND VGND VPWR VPWR _2750_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7961_ _3011_ net1072 _3938_ VGND VGND VPWR VPWR _3947_ sky130_fd_sc_hd__mux2_1
X_7892_ _3910_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6912_ _3374_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__clkbuf_1
X_6843_ _3337_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9562_ clknet_leaf_24_CLK _0722_ VGND VGND VPWR VPWR regfile.registers\[11\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6774_ net501 _3017_ _3266_ VGND VGND VPWR VPWR _3301_ sky130_fd_sc_hd__mux2_1
X_9493_ clknet_leaf_34_CLK _0653_ VGND VGND VPWR VPWR regfile.registers\[16\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5725_ _1125_ _1145_ _1167_ _2411_ VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__a31o_1
X_8513_ _4239_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5656_ _2409_ VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__buf_2
XFILLER_0_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8444_ net207 net40 _4168_ VGND VGND VPWR VPWR _4203_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4607_ regfile.registers\[12\]\[25\] regfile.registers\[13\]\[25\] regfile.registers\[14\]\[25\]
+ regfile.registers\[15\]\[25\] _1360_ _1361_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_107_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5587_ _1667_ _2124_ VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__or2_1
X_8375_ _4166_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__clkbuf_1
Xhold320 regfile.registers\[25\]\[7\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold353 regfile.registers\[17\]\[22\] VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__dlygate4sd3_1
Xhold342 regfile.registers\[9\]\[26\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd3_1
X_4538_ regfile.registers\[8\]\[26\] regfile.registers\[9\]\[26\] regfile.registers\[10\]\[26\]
+ regfile.registers\[11\]\[26\] _1172_ _1279_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold331 regfile.registers\[21\]\[11\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
X_7326_ _3610_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
Xhold386 regfile.registers\[11\]\[25\] VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__dlygate4sd3_1
Xhold375 regfile.registers\[25\]\[23\] VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__dlygate4sd3_1
X_4469_ regfile.registers\[28\]\[28\] regfile.registers\[29\]\[28\] regfile.registers\[30\]\[28\]
+ regfile.registers\[31\]\[28\] net1150 _1222_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__mux4_2
Xhold364 regfile.registers\[9\]\[9\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd3_1
X_7257_ net267 _3529_ _3564_ VGND VGND VPWR VPWR _3573_ sky130_fd_sc_hd__mux2_1
X_6208_ _2893_ _2935_ VGND VGND VPWR VPWR _2936_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold397 regfile.registers\[9\]\[20\] VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7188_ _3491_ VGND VGND VPWR VPWR _3534_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_5_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6139_ _1512_ _2835_ _1635_ _2658_ VGND VGND VPWR VPWR _2871_ sky130_fd_sc_hd__and4_1
Xhold1042 regfile.registers\[31\]\[11\] VGND VGND VPWR VPWR net1122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1020 regfile.registers\[28\]\[2\] VGND VGND VPWR VPWR net1100 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1031 regfile.registers\[23\]\[6\] VGND VGND VPWR VPWR net1111 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_116_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1053 regfile.registers\[16\]\[2\] VGND VGND VPWR VPWR net1133 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_125_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer9 _2506_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_750 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_125_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5510_ _1699_ _2265_ VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__nand2_1
X_6490_ _3148_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5441_ _2195_ _2196_ _1711_ VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__mux2_1
X_8160_ net942 _3544_ _4047_ VGND VGND VPWR VPWR _4053_ sky130_fd_sc_hd__mux2_1
X_5372_ regfile.registers\[28\]\[14\] regfile.registers\[29\]\[14\] regfile.registers\[30\]\[14\]
+ regfile.registers\[31\]\[14\] _1674_ _1691_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__mux4_1
X_8091_ _4016_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__clkbuf_1
X_7111_ _3481_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4323_ regfile.registers\[4\]\[5\] regfile.registers\[5\]\[5\] regfile.registers\[6\]\[5\]
+ regfile.registers\[7\]\[5\] net96 _1044_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux4_1
XFILLER_0_129_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7042_ _3443_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_129_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8993_ clknet_leaf_84_CLK _0153_ VGND VGND VPWR VPWR regfile.registers\[29\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7944_ _3915_ VGND VGND VPWR VPWR _3938_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_54_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7875_ _3901_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__clkbuf_1
X_6826_ _3071_ net805 _3325_ VGND VGND VPWR VPWR _3329_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6757_ _3292_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9545_ clknet_leaf_99_CLK _0705_ VGND VGND VPWR VPWR regfile.registers\[11\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_5708_ _2346_ _2351_ _2327_ VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6688_ _3069_ net1098 _3253_ VGND VGND VPWR VPWR _3256_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9476_ clknet_leaf_93_CLK _0636_ VGND VGND VPWR VPWR regfile.registers\[16\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5639_ _1168_ _1755_ VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8427_ _4194_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_98_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8358_ net725 _3538_ _4155_ VGND VGND VPWR VPWR _4158_ sky130_fd_sc_hd__mux2_1
X_7309_ _3601_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
Xhold150 regfile.registers\[18\]\[17\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold161 regfile.registers\[6\]\[17\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
X_8289_ _4121_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__clkbuf_1
Xhold194 regfile.registers\[11\]\[30\] VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 regfile.registers\[9\]\[19\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 regfile.registers\[17\]\[10\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5990_ _2041_ _2102_ VGND VGND VPWR VPWR _2730_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4941_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__buf_6
X_4872_ _1626_ _1627_ _1189_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7660_ net459 _3521_ _3783_ VGND VGND VPWR VPWR _3788_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_82_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6611_ _3214_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9330_ clknet_leaf_48_CLK _0490_ VGND VGND VPWR VPWR regfile.registers\[21\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_7591_ _3751_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_15_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6542_ _3176_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_92_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_92_CLK sky130_fd_sc_hd__clkbuf_8
X_6473_ net936 _3137_ _3135_ VGND VGND VPWR VPWR _3138_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9261_ clknet_leaf_11_CLK _0421_ VGND VGND VPWR VPWR regfile.registers\[18\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_9192_ clknet_leaf_102_CLK _0352_ VGND VGND VPWR VPWR regfile.registers\[30\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_5424_ regfile.registers\[24\]\[11\] regfile.registers\[25\]\[11\] regfile.registers\[26\]\[11\]
+ regfile.registers\[27\]\[11\] _1675_ _1692_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__mux4_1
X_8212_ _4080_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8143_ net775 _3527_ _4036_ VGND VGND VPWR VPWR _4044_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5355_ regfile.registers\[8\]\[15\] regfile.registers\[9\]\[15\] regfile.registers\[10\]\[15\]
+ regfile.registers\[11\]\[15\] _1703_ _1706_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__mux4_1
XFILLER_0_49_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8074_ _4007_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__clkbuf_1
X_5286_ regfile.registers\[20\]\[3\] regfile.registers\[21\]\[3\] regfile.registers\[22\]\[3\]
+ regfile.registers\[23\]\[3\] _1674_ _1691_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__mux4_1
X_4306_ regfile.registers\[20\]\[5\] regfile.registers\[21\]\[5\] regfile.registers\[22\]\[5\]
+ regfile.registers\[23\]\[5\] net87 _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__mux4_1
X_7025_ net144 _3134_ _3434_ VGND VGND VPWR VPWR _3435_ sky130_fd_sc_hd__mux2_1
X_8976_ clknet_leaf_9_CLK _0136_ VGND VGND VPWR VPWR regfile.registers\[7\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7927_ _3929_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7858_ net317 _3515_ _3891_ VGND VGND VPWR VPWR _3893_ sky130_fd_sc_hd__mux2_1
X_6809_ _3054_ net1120 _3314_ VGND VGND VPWR VPWR _3320_ sky130_fd_sc_hd__mux2_1
X_7789_ _3856_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__clkbuf_1
X_9528_ clknet_leaf_17_CLK _0688_ VGND VGND VPWR VPWR regfile.registers\[12\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_83_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_83_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9459_ clknet_leaf_34_CLK _0619_ VGND VGND VPWR VPWR regfile.registers\[13\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_74_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_74_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_114_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold919 regfile.registers\[31\]\[29\] VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__dlygate4sd3_1
Xhold908 regfile.registers\[17\]\[2\] VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_736 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5140_ _1895_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__buf_4
X_5071_ regfile.registers\[20\]\[19\] regfile.registers\[21\]\[19\] regfile.registers\[22\]\[19\]
+ regfile.registers\[23\]\[19\] _1676_ _1681_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__mux4_1
XFILLER_0_126_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8830_ clknet_leaf_68_CLK _1014_ VGND VGND VPWR VPWR regfile.registers\[5\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_126_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8761_ clknet_leaf_38_CLK _0945_ VGND VGND VPWR VPWR regfile.registers\[8\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5973_ net92 _2714_ VGND VGND VPWR VPWR _2715_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_84_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7712_ _3815_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__clkbuf_1
X_4924_ _1679_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__buf_4
X_8692_ clknet_leaf_41_CLK _0876_ VGND VGND VPWR VPWR regfile.registers\[0\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4855_ _1211_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__or2_1
X_7643_ net969 _3504_ _3772_ VGND VGND VPWR VPWR _3779_ sky130_fd_sc_hd__mux2_1
X_4786_ _1025_ _1533_ _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__o21ai_4
X_7574_ _3742_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_65_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_65_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_105_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9313_ clknet_leaf_84_CLK _0473_ VGND VGND VPWR VPWR regfile.registers\[21\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6525_ _3046_ net582 _3166_ VGND VGND VPWR VPWR _3168_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9244_ clknet_leaf_43_CLK _0404_ VGND VGND VPWR VPWR regfile.registers\[9\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_95_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6456_ net23 VGND VGND VPWR VPWR _3126_ sky130_fd_sc_hd__buf_2
Xclkload70 clknet_leaf_91_CLK VGND VGND VPWR VPWR clkload70/Y sky130_fd_sc_hd__clkinvlp_4
X_9175_ clknet_leaf_51_CLK _0335_ VGND VGND VPWR VPWR regfile.registers\[2\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkload92 clknet_leaf_47_CLK VGND VGND VPWR VPWR clkload92/Y sky130_fd_sc_hd__clkinvlp_4
X_6387_ _3078_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__clkbuf_1
X_5407_ regfile.registers\[28\]\[12\] regfile.registers\[29\]\[12\] regfile.registers\[30\]\[12\]
+ regfile.registers\[31\]\[12\] _1703_ _1706_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__mux4_1
Xclkload81 clknet_leaf_72_CLK VGND VGND VPWR VPWR clkload81/Y sky130_fd_sc_hd__inv_8
X_8126_ net880 _3510_ _4025_ VGND VGND VPWR VPWR _4035_ sky130_fd_sc_hd__mux2_1
X_5338_ regfile.registers\[12\]\[1\] regfile.registers\[13\]\[1\] regfile.registers\[14\]\[1\]
+ regfile.registers\[15\]\[1\] _1641_ _1642_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__mux4_1
X_8057_ _3998_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__clkbuf_1
X_5269_ regfile.registers\[12\]\[24\] regfile.registers\[13\]\[24\] regfile.registers\[14\]\[24\]
+ regfile.registers\[15\]\[24\] _1881_ _1883_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__mux4_1
X_7008_ net577 _3118_ _3423_ VGND VGND VPWR VPWR _3426_ sky130_fd_sc_hd__mux2_1
X_8959_ clknet_leaf_75_CLK _0119_ VGND VGND VPWR VPWR regfile.registers\[7\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_748 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_56_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_56_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_33_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_47_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_47_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4640_ regfile.registers\[0\]\[6\] regfile.registers\[1\]\[6\] regfile.registers\[2\]\[6\]
+ regfile.registers\[3\]\[6\] net97 _1073_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__mux4_1
XFILLER_0_115_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4571_ _1178_ _1326_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6310_ _3026_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__clkbuf_1
Xhold716 regfile.registers\[25\]\[21\] VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold705 regfile.registers\[11\]\[26\] VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dlygate4sd3_1
Xhold727 regfile.registers\[14\]\[16\] VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlygate4sd3_1
X_7290_ _3019_ net1019 _3591_ VGND VGND VPWR VPWR _3592_ sky130_fd_sc_hd__mux2_1
XFILLER_0_122_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold738 regfile.registers\[12\]\[24\] VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6241_ _2547_ VGND VGND VPWR VPWR _2967_ sky130_fd_sc_hd__inv_2
Xhold749 regfile.registers\[23\]\[0\] VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlygate4sd3_1
X_6172_ _1447_ _2901_ _2871_ _2741_ VGND VGND VPWR VPWR _2902_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5123_ _1126_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_20_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5054_ _1808_ _1809_ _1739_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8813_ clknet_leaf_94_CLK _0997_ VGND VGND VPWR VPWR regfile.registers\[6\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5956_ _2610_ _2698_ _2251_ VGND VGND VPWR VPWR _2699_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8744_ clknet_leaf_88_CLK _0928_ VGND VGND VPWR VPWR regfile.registers\[8\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_4907_ _1148_ _1662_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__nand2_1
X_5887_ _2632_ _2210_ VGND VGND VPWR VPWR _2633_ sky130_fd_sc_hd__xor2_1
X_8675_ clknet_leaf_90_CLK _0859_ VGND VGND VPWR VPWR regfile.registers\[0\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_38_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_38_CLK sky130_fd_sc_hd__clkbuf_8
X_7626_ _3769_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4838_ regfile.registers\[12\]\[17\] regfile.registers\[13\]\[17\] regfile.registers\[14\]\[17\]
+ regfile.registers\[15\]\[17\] _1191_ _1279_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__mux4_1
XFILLER_0_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7557_ _3085_ net930 _3699_ VGND VGND VPWR VPWR _3733_ sky130_fd_sc_hd__mux2_1
X_4769_ regfile.registers\[0\]\[8\] regfile.registers\[1\]\[8\] regfile.registers\[2\]\[8\]
+ regfile.registers\[3\]\[8\] _1149_ _1028_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__mux4_1
XFILLER_0_31_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7488_ _3696_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
X_6508_ _3029_ net473 _3155_ VGND VGND VPWR VPWR _3159_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6439_ net252 _3113_ _3114_ VGND VGND VPWR VPWR _3115_ sky130_fd_sc_hd__mux2_1
X_9227_ clknet_leaf_98_CLK _0387_ VGND VGND VPWR VPWR regfile.registers\[9\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9158_ clknet_leaf_56_CLK _0318_ VGND VGND VPWR VPWR regfile.registers\[2\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8109_ _4026_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__clkbuf_1
X_9089_ clknet_leaf_84_CLK _0249_ VGND VGND VPWR VPWR regfile.registers\[27\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold54 regfile.registers\[7\]\[31\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 regfile.registers\[5\]\[9\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 regfile.registers\[1\]\[16\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 regfile.registers\[18\]\[25\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 regfile.registers\[5\]\[14\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 regfile.registers\[11\]\[15\] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_29_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_29_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_123_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5810_ _2286_ _2558_ VGND VGND VPWR VPWR _2559_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6790_ _3035_ net895 _3303_ VGND VGND VPWR VPWR _3310_ sky130_fd_sc_hd__mux2_1
X_5741_ _2250_ _2255_ _2492_ _2373_ VGND VGND VPWR VPWR _2493_ sky130_fd_sc_hd__o211a_1
XFILLER_0_9_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8460_ net755 net44 _4205_ VGND VGND VPWR VPWR _4212_ sky130_fd_sc_hd__mux2_1
X_7411_ _3655_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
X_5672_ _1879_ VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4623_ _1214_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8391_ _4175_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__clkbuf_1
X_7342_ _3075_ net272 _3613_ VGND VGND VPWR VPWR _3619_ sky130_fd_sc_hd__mux2_1
X_4554_ _1254_ _1309_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__nor2_1
Xhold502 regfile.registers\[22\]\[11\] VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlygate4sd3_1
X_7273_ _3581_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_92_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold535 regfile.registers\[15\]\[31\] VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__dlygate4sd3_1
Xhold524 regfile.registers\[8\]\[14\] VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__dlygate4sd3_1
Xhold513 regfile.registers\[3\]\[16\] VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__dlygate4sd3_1
X_6224_ _1942_ _2950_ VGND VGND VPWR VPWR _2951_ sky130_fd_sc_hd__and2_1
Xhold546 regfile.registers\[31\]\[20\] VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__dlygate4sd3_1
X_9012_ clknet_leaf_22_CLK _0172_ VGND VGND VPWR VPWR regfile.registers\[29\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_92_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4485_ regfile.registers\[16\]\[20\] regfile.registers\[17\]\[20\] regfile.registers\[18\]\[20\]
+ regfile.registers\[19\]\[20\] _1207_ _1208_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__mux4_1
Xhold579 regfile.registers\[14\]\[20\] VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlygate4sd3_1
Xhold557 regfile.registers\[2\]\[18\] VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__dlygate4sd3_1
Xhold568 regfile.registers\[24\]\[2\] VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6155_ _2863_ _2870_ _2886_ _2408_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__o22a_1
X_6086_ _2790_ _2820_ _1146_ VGND VGND VPWR VPWR _2821_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5106_ regfile.registers\[28\]\[16\] regfile.registers\[29\]\[16\] regfile.registers\[30\]\[16\]
+ regfile.registers\[31\]\[16\] _1720_ _1723_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__mux4_1
X_5037_ _1712_ _1792_ _1716_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8727_ clknet_leaf_36_CLK _0911_ VGND VGND VPWR VPWR regfile.registers\[15\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6988_ _3415_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5939_ _2504_ _2671_ _2682_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__a21oi_2
XFILLER_0_48_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8658_ clknet_leaf_49_CLK _0842_ VGND VGND VPWR VPWR regfile.registers\[22\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7609_ _3069_ net553 _3758_ VGND VGND VPWR VPWR _3761_ sky130_fd_sc_hd__mux2_1
X_8589_ clknet_leaf_11_CLK _0773_ VGND VGND VPWR VPWR regfile.registers\[23\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput66 net66 VGND VGND VPWR VPWR ALUResult[25] sky130_fd_sc_hd__clkbuf_4
Xoutput55 net55 VGND VGND VPWR VPWR ALUResult[15] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput77 net77 VGND VGND VPWR VPWR ALUResult[6] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4270_ A2[0] VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__buf_12
Xclkbuf_leaf_9_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_9_CLK sky130_fd_sc_hd__clkbuf_8
X_7960_ _3946_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__clkbuf_1
X_7891_ net131 _3480_ _3902_ VGND VGND VPWR VPWR _3910_ sky130_fd_sc_hd__mux2_1
X_6911_ net303 _3017_ _3339_ VGND VGND VPWR VPWR _3374_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6842_ _3087_ net751 _3302_ VGND VGND VPWR VPWR _3337_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9561_ clknet_leaf_38_CLK _0721_ VGND VGND VPWR VPWR regfile.registers\[11\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6773_ _3300_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5724_ _2468_ _2476_ VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__and2_1
X_9492_ clknet_leaf_23_CLK _0652_ VGND VGND VPWR VPWR regfile.registers\[16\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_8512_ net202 net40 _4204_ VGND VGND VPWR VPWR _4239_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8443_ _4202_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__clkbuf_1
X_5655_ _1145_ _1166_ _2409_ VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__or3_1
XFILLER_0_33_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4606_ regfile.registers\[8\]\[25\] regfile.registers\[9\]\[25\] regfile.registers\[10\]\[25\]
+ regfile.registers\[11\]\[25\] _1360_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__mux4_1
X_8374_ net439 _3486_ _4132_ VGND VGND VPWR VPWR _4166_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5586_ _1758_ _1874_ _1839_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__o21a_1
X_7325_ _3058_ net1036 _3602_ VGND VGND VPWR VPWR _3610_ sky130_fd_sc_hd__mux2_1
Xhold310 regfile.registers\[3\]\[17\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
Xhold321 regfile.registers\[0\]\[27\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold343 regfile.registers\[10\]\[30\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__dlygate4sd3_1
X_4537_ _1198_ _1292_ _1071_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__a21o_1
Xhold332 regfile.registers\[20\]\[7\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4468_ _1218_ _1223_ _1178_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__mux2_1
Xhold354 regfile.registers\[9\]\[18\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__dlygate4sd3_1
Xhold376 regfile.registers\[18\]\[3\] VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold365 regfile.registers\[10\]\[6\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__dlygate4sd3_1
Xhold387 regfile.registers\[17\]\[17\] VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlygate4sd3_1
X_7256_ _3572_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_111_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6207_ _2904_ _2918_ VGND VGND VPWR VPWR _2935_ sky130_fd_sc_hd__nand2_1
X_7187_ net28 VGND VGND VPWR VPWR _3533_ sky130_fd_sc_hd__buf_2
Xhold398 regfile.registers\[23\]\[15\] VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__dlygate4sd3_1
X_6138_ _2504_ _2865_ _2869_ VGND VGND VPWR VPWR _2870_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_5_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4399_ regfile.registers\[24\]\[0\] regfile.registers\[25\]\[0\] regfile.registers\[26\]\[0\]
+ regfile.registers\[27\]\[0\] _1149_ _1028_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__mux4_1
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1010 regfile.registers\[20\]\[2\] VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1021 regfile.registers\[21\]\[2\] VGND VGND VPWR VPWR net1101 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1032 regfile.registers\[22\]\[14\] VGND VGND VPWR VPWR net1112 sky130_fd_sc_hd__dlygate4sd3_1
X_6069_ _1256_ _2804_ VGND VGND VPWR VPWR _2805_ sky130_fd_sc_hd__xor2_1
Xhold1054 regfile.registers\[11\]\[22\] VGND VGND VPWR VPWR net1134 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1043 regfile.registers\[27\]\[11\] VGND VGND VPWR VPWR net1123 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_24_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_4__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_4__leaf_CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_125_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5440_ regfile.registers\[28\]\[10\] regfile.registers\[29\]\[10\] regfile.registers\[30\]\[10\]
+ regfile.registers\[31\]\[10\] _1674_ _1691_ VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__mux4_1
XFILLER_0_15_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5371_ _2125_ _2126_ _2044_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__mux2_1
X_8090_ net313 _3542_ _4011_ VGND VGND VPWR VPWR _4016_ sky130_fd_sc_hd__mux2_1
X_7110_ net186 _3480_ _3471_ VGND VGND VPWR VPWR _3481_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4322_ _1050_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__clkbuf_8
X_7041_ net756 _3011_ _3434_ VGND VGND VPWR VPWR _3443_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8992_ clknet_leaf_78_CLK _0152_ VGND VGND VPWR VPWR regfile.registers\[29\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7943_ _3937_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7874_ net977 _3531_ _3891_ VGND VGND VPWR VPWR _3901_ sky130_fd_sc_hd__mux2_1
X_6825_ _3328_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6756_ net504 _3139_ _3289_ VGND VGND VPWR VPWR _3292_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9544_ clknet_leaf_101_CLK _0704_ VGND VGND VPWR VPWR regfile.registers\[11\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_5707_ _2402_ _2343_ _2327_ VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6687_ _3255_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__clkbuf_1
X_9475_ clknet_leaf_81_CLK _0635_ VGND VGND VPWR VPWR regfile.registers\[16\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_5638_ _2391_ _2392_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8426_ net332 _3538_ _4191_ VGND VGND VPWR VPWR _4194_ sky130_fd_sc_hd__mux2_1
X_8357_ _4157_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__clkbuf_1
X_5569_ _1839_ _2324_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__nand2_1
Xhold140 regfile.registers\[1\]\[28\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
Xhold151 regfile.registers\[17\]\[9\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
X_7308_ _3041_ net407 _3591_ VGND VGND VPWR VPWR _3601_ sky130_fd_sc_hd__mux2_1
Xhold162 regfile.registers\[1\]\[2\] VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
X_8288_ _3137_ net809 _4119_ VGND VGND VPWR VPWR _4121_ sky130_fd_sc_hd__mux2_1
Xhold173 regfile.registers\[18\]\[28\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 regfile.registers\[16\]\[20\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 regfile.registers\[1\]\[8\] VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7239_ _3563_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_95_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4940_ net4 VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4871_ regfile.registers\[12\]\[18\] regfile.registers\[13\]\[18\] regfile.registers\[14\]\[18\]
+ regfile.registers\[15\]\[18\] _1192_ _1195_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux4_1
XFILLER_0_115_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6610_ net963 _3130_ _3205_ VGND VGND VPWR VPWR _3214_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_715 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7590_ _3050_ net1046 _3747_ VGND VGND VPWR VPWR _3751_ sky130_fd_sc_hd__mux2_1
X_6541_ _3062_ net893 _3166_ VGND VGND VPWR VPWR _3176_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6472_ net29 VGND VGND VPWR VPWR _3137_ sky130_fd_sc_hd__buf_2
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9260_ clknet_leaf_111_CLK _0420_ VGND VGND VPWR VPWR regfile.registers\[18\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5423_ _2143_ _2177_ _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9191_ clknet_leaf_61_CLK _0351_ VGND VGND VPWR VPWR regfile.registers\[30\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8211_ net389 _3527_ _4072_ VGND VGND VPWR VPWR _4080_ sky130_fd_sc_hd__mux2_1
X_8142_ _4043_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__clkbuf_1
X_5354_ _2106_ _2107_ _2108_ _2109_ _1685_ _1696_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__mux4_2
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4305_ A2[1] VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__clkbuf_4
X_5285_ _1880_ _2038_ _2040_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__mux2_2
X_8073_ net356 _3525_ _4000_ VGND VGND VPWR VPWR _4007_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7024_ _3411_ VGND VGND VPWR VPWR _3434_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8975_ clknet_leaf_1_CLK _0135_ VGND VGND VPWR VPWR regfile.registers\[7\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7926_ _3116_ net511 _3927_ VGND VGND VPWR VPWR _3929_ sky130_fd_sc_hd__mux2_1
X_7857_ _3892_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6808_ _3319_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7788_ net397 _3512_ _3855_ VGND VGND VPWR VPWR _3856_ sky130_fd_sc_hd__mux2_1
X_9527_ clknet_leaf_36_CLK _0687_ VGND VGND VPWR VPWR regfile.registers\[12\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_6739_ net604 _3122_ _3278_ VGND VGND VPWR VPWR _3283_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9458_ clknet_leaf_45_CLK _0618_ VGND VGND VPWR VPWR regfile.registers\[13\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8409_ net789 _3521_ _4180_ VGND VGND VPWR VPWR _4185_ sky130_fd_sc_hd__mux2_1
X_9389_ clknet_leaf_95_CLK _0549_ VGND VGND VPWR VPWR regfile.registers\[24\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_103_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold909 regfile.registers\[30\]\[29\] VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5070_ regfile.registers\[16\]\[19\] regfile.registers\[17\]\[19\] regfile.registers\[18\]\[19\]
+ regfile.registers\[19\]\[19\] _1676_ _1681_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__mux4_1
XFILLER_0_126_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5972_ _2669_ _2689_ _2713_ VGND VGND VPWR VPWR _2714_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_84_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8760_ clknet_leaf_18_CLK _0944_ VGND VGND VPWR VPWR regfile.registers\[8\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7711_ _3035_ net1031 _3808_ VGND VGND VPWR VPWR _3815_ sky130_fd_sc_hd__mux2_1
X_4923_ _1678_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__buf_4
XFILLER_0_129_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8691_ clknet_leaf_39_CLK _0875_ VGND VGND VPWR VPWR regfile.registers\[0\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4854_ regfile.registers\[4\]\[19\] regfile.registers\[5\]\[19\] regfile.registers\[6\]\[19\]
+ regfile.registers\[7\]\[19\] _1173_ _1175_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__mux4_1
X_7642_ _3778_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4785_ _1535_ _1537_ _1540_ _1088_ net8 VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__a221o_1
X_7573_ _3033_ net1107 _3736_ VGND VGND VPWR VPWR _3742_ sky130_fd_sc_hd__mux2_1
X_6524_ _3167_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__clkbuf_1
X_9312_ clknet_leaf_77_CLK _0472_ VGND VGND VPWR VPWR regfile.registers\[21\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9243_ clknet_leaf_40_CLK _0403_ VGND VGND VPWR VPWR regfile.registers\[9\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload60 clknet_leaf_46_CLK VGND VGND VPWR VPWR clkload60/Y sky130_fd_sc_hd__clkinv_4
X_6455_ _3125_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__clkbuf_1
Xclkload71 clknet_leaf_92_CLK VGND VGND VPWR VPWR clkload71/X sky130_fd_sc_hd__clkbuf_4
X_9174_ clknet_leaf_52_CLK _0334_ VGND VGND VPWR VPWR regfile.registers\[2\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkload93 clknet_leaf_50_CLK VGND VGND VPWR VPWR clkload93/Y sky130_fd_sc_hd__clkinv_1
X_6386_ _3077_ net1043 _3065_ VGND VGND VPWR VPWR _3078_ sky130_fd_sc_hd__mux2_1
X_5406_ regfile.registers\[24\]\[12\] regfile.registers\[25\]\[12\] regfile.registers\[26\]\[12\]
+ regfile.registers\[27\]\[12\] _2113_ _2114_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__mux4_1
Xclkload82 clknet_leaf_73_CLK VGND VGND VPWR VPWR clkload82/Y sky130_fd_sc_hd__inv_6
X_8125_ _4034_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_10_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5337_ regfile.registers\[8\]\[1\] regfile.registers\[9\]\[1\] regfile.registers\[10\]\[1\]
+ regfile.registers\[11\]\[1\] _1641_ _1642_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__mux4_1
X_5268_ _2020_ _2023_ _1766_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8056_ net581 _3508_ _3989_ VGND VGND VPWR VPWR _3998_ sky130_fd_sc_hd__mux2_1
X_7007_ _3425_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_5199_ regfile.registers\[12\]\[28\] regfile.registers\[13\]\[28\] regfile.registers\[14\]\[28\]
+ regfile.registers\[15\]\[28\] _1896_ _1898_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__mux4_1
XFILLER_0_97_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8958_ clknet_leaf_66_CLK _0118_ VGND VGND VPWR VPWR regfile.registers\[7\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_7909_ _3099_ net409 _3916_ VGND VGND VPWR VPWR _3920_ sky130_fd_sc_hd__mux2_1
X_8889_ clknet_leaf_48_CLK _0049_ VGND VGND VPWR VPWR regfile.registers\[4\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_104_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4570_ regfile.registers\[8\]\[31\] regfile.registers\[9\]\[31\] regfile.registers\[10\]\[31\]
+ regfile.registers\[11\]\[31\] _1324_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__mux4_1
XFILLER_0_25_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold717 regfile.registers\[15\]\[12\] VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold728 regfile.registers\[0\]\[3\] VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlygate4sd3_1
Xhold706 regfile.registers\[13\]\[18\] VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlygate4sd3_1
X_6240_ _2442_ _2942_ VGND VGND VPWR VPWR _2966_ sky130_fd_sc_hd__or2_1
Xhold739 regfile.registers\[24\]\[29\] VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6171_ _1385_ VGND VGND VPWR VPWR _2901_ sky130_fd_sc_hd__inv_2
XFILLER_0_110_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5122_ _1841_ _1876_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_90_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5053_ regfile.registers\[24\]\[18\] regfile.registers\[25\]\[18\] regfile.registers\[26\]\[18\]
+ regfile.registers\[27\]\[18\] _1734_ _1735_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__mux4_1
X_8812_ clknet_leaf_0_CLK _0996_ VGND VGND VPWR VPWR regfile.registers\[6\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5955_ _2649_ _2697_ _1803_ VGND VGND VPWR VPWR _2698_ sky130_fd_sc_hd__mux2_1
X_8743_ clknet_leaf_59_CLK _0927_ VGND VGND VPWR VPWR regfile.registers\[8\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4906_ _1169_ _1661_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__and2_1
X_5886_ _1558_ _2631_ VGND VGND VPWR VPWR _2632_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8674_ clknet_leaf_88_CLK _0858_ VGND VGND VPWR VPWR regfile.registers\[0\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7625_ _3085_ net1127 _3735_ VGND VGND VPWR VPWR _3769_ sky130_fd_sc_hd__mux2_1
X_4837_ regfile.registers\[8\]\[17\] regfile.registers\[9\]\[17\] regfile.registers\[10\]\[17\]
+ regfile.registers\[11\]\[17\] _1191_ _1174_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__mux4_1
X_7556_ _3732_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
X_4768_ regfile.registers\[4\]\[8\] regfile.registers\[5\]\[8\] regfile.registers\[6\]\[8\]
+ regfile.registers\[7\]\[8\] _1149_ _1028_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__mux4_1
XFILLER_0_16_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7487_ _3083_ net904 _3686_ VGND VGND VPWR VPWR _3696_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4699_ _1451_ _1454_ _1071_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__mux2_1
X_6507_ _3158_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__clkbuf_1
X_6438_ _3092_ VGND VGND VPWR VPWR _3114_ sky130_fd_sc_hd__clkbuf_8
X_9226_ clknet_leaf_106_CLK _0386_ VGND VGND VPWR VPWR regfile.registers\[9\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_9157_ clknet_leaf_93_CLK _0317_ VGND VGND VPWR VPWR regfile.registers\[2\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_6369_ _3066_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__clkbuf_1
X_8108_ net777 _3490_ _4025_ VGND VGND VPWR VPWR _4026_ sky130_fd_sc_hd__mux2_1
X_9088_ clknet_leaf_78_CLK _0248_ VGND VGND VPWR VPWR regfile.registers\[27\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold44 regfile.registers\[4\]\[25\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 regfile.registers\[5\]\[20\] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
X_8039_ _3988_ VGND VGND VPWR VPWR _3989_ sky130_fd_sc_hd__buf_6
Xhold33 regfile.registers\[16\]\[0\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 regfile.registers\[6\]\[25\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 regfile.registers\[0\]\[9\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 regfile.registers\[19\]\[8\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 regfile.registers\[12\]\[2\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_738 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5740_ _2336_ _2328_ VGND VGND VPWR VPWR _2492_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7410_ _3075_ net692 _3649_ VGND VGND VPWR VPWR _3655_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5671_ _2177_ _2213_ _2363_ VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4622_ _1376_ _1377_ _1199_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8390_ net418 _3502_ _4169_ VGND VGND VPWR VPWR _4175_ sky130_fd_sc_hd__mux2_1
X_7341_ _3618_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4553_ _1307_ _1308_ _1199_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold514 regfile.registers\[24\]\[23\] VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__dlygate4sd3_1
X_7272_ net308 _3544_ _3575_ VGND VGND VPWR VPWR _3581_ sky130_fd_sc_hd__mux2_1
X_4484_ regfile.registers\[20\]\[20\] regfile.registers\[21\]\[20\] regfile.registers\[22\]\[20\]
+ regfile.registers\[23\]\[20\] _1207_ _1208_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_92_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold525 regfile.registers\[4\]\[19\] VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__dlygate4sd3_1
Xhold503 regfile.registers\[16\]\[19\] VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__dlygate4sd3_1
Xhold536 regfile.registers\[5\]\[1\] VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlygate4sd3_1
Xhold569 regfile.registers\[29\]\[21\] VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__dlygate4sd3_1
X_9011_ clknet_leaf_27_CLK _0171_ VGND VGND VPWR VPWR regfile.registers\[29\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_110_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6223_ net112 _2949_ VGND VGND VPWR VPWR _2950_ sky130_fd_sc_hd__xnor2_1
Xhold558 regfile.registers\[19\]\[19\] VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__dlygate4sd3_1
Xhold547 regfile.registers\[7\]\[3\] VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6154_ _2884_ _2885_ VGND VGND VPWR VPWR _2886_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6085_ _2398_ _2395_ VGND VGND VPWR VPWR _2820_ sky130_fd_sc_hd__nor2_1
X_5105_ regfile.registers\[24\]\[16\] regfile.registers\[25\]\[16\] regfile.registers\[26\]\[16\]
+ regfile.registers\[27\]\[16\] _1705_ _1708_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__mux4_1
X_5036_ regfile.registers\[12\]\[20\] regfile.registers\[13\]\[20\] regfile.registers\[14\]\[20\]
+ regfile.registers\[15\]\[20\] _1719_ _1722_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6987_ net773 _3097_ _3412_ VGND VGND VPWR VPWR _3415_ sky130_fd_sc_hd__mux2_1
X_8726_ clknet_leaf_49_CLK _0910_ VGND VGND VPWR VPWR regfile.registers\[15\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_5938_ _1087_ _2678_ _2681_ VGND VGND VPWR VPWR _2682_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_101_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5869_ _2615_ _1542_ VGND VGND VPWR VPWR _2616_ sky130_fd_sc_hd__xnor2_2
X_8657_ clknet_leaf_18_CLK _0841_ VGND VGND VPWR VPWR regfile.registers\[22\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_7608_ _3760_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8588_ clknet_leaf_110_CLK _0772_ VGND VGND VPWR VPWR regfile.registers\[23\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_7539_ _3067_ net958 _3722_ VGND VGND VPWR VPWR _3724_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9209_ clknet_leaf_33_CLK _0369_ VGND VGND VPWR VPWR regfile.registers\[30\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput67 net67 VGND VGND VPWR VPWR ALUResult[26] sky130_fd_sc_hd__clkbuf_4
Xoutput56 net56 VGND VGND VPWR VPWR ALUResult[16] sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_112_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput78 net78 VGND VGND VPWR VPWR ALUResult[7] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7890_ _3909_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__clkbuf_1
X_6910_ _3373_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__clkbuf_1
X_6841_ _3336_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__clkbuf_1
X_9560_ clknet_leaf_18_CLK _0720_ VGND VGND VPWR VPWR regfile.registers\[11\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_85_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8511_ _4238_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__clkbuf_1
X_6772_ net357 _3015_ _3266_ VGND VGND VPWR VPWR _3300_ sky130_fd_sc_hd__mux2_1
X_9491_ clknet_leaf_29_CLK _0651_ VGND VGND VPWR VPWR regfile.registers\[16\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5723_ _2471_ _2475_ _2040_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__mux2_1
X_5654_ _1664_ net15 VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__nor2_1
X_8442_ net696 net39 _4168_ VGND VGND VPWR VPWR _4202_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4605_ _1352_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__clkbuf_4
X_8373_ _4165_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold300 regfile.registers\[6\]\[21\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_103_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5585_ _2178_ _2339_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__nand2_1
Xhold311 regfile.registers\[17\]\[19\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7324_ _3609_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
Xhold344 regfile.registers\[9\]\[28\] VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd3_1
X_4536_ regfile.registers\[0\]\[26\] regfile.registers\[1\]\[26\] regfile.registers\[2\]\[26\]
+ regfile.registers\[3\]\[26\] _1291_ _1194_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__mux4_1
Xhold333 regfile.registers\[27\]\[9\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold322 regfile.registers\[11\]\[17\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
Xhold355 regfile.registers\[11\]\[23\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4467_ regfile.registers\[16\]\[28\] regfile.registers\[17\]\[28\] regfile.registers\[18\]\[28\]
+ regfile.registers\[19\]\[28\] _1220_ _1222_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__mux4_1
XFILLER_0_40_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold366 regfile.registers\[3\]\[12\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__dlygate4sd3_1
X_7255_ net550 _3527_ _3564_ VGND VGND VPWR VPWR _3572_ sky130_fd_sc_hd__mux2_1
Xhold377 regfile.registers\[0\]\[16\] VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd3_1
X_6206_ _2932_ _2933_ VGND VGND VPWR VPWR _2934_ sky130_fd_sc_hd__nor2_1
X_7186_ _3532_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
Xhold399 regfile.registers\[17\]\[1\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__dlygate4sd3_1
Xhold388 regfile.registers\[13\]\[14\] VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__dlygate4sd3_1
X_4398_ regfile.registers\[28\]\[0\] regfile.registers\[29\]\[0\] regfile.registers\[30\]\[0\]
+ regfile.registers\[31\]\[0\] _1149_ _1028_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__mux4_1
XFILLER_0_110_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6137_ _2104_ _2736_ _2868_ _1086_ VGND VGND VPWR VPWR _2869_ sky130_fd_sc_hd__o211a_1
Xhold1000 regfile.registers\[15\]\[26\] VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1022 regfile.registers\[17\]\[30\] VGND VGND VPWR VPWR net1102 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1011 regfile.registers\[22\]\[13\] VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1033 regfile.registers\[26\]\[2\] VGND VGND VPWR VPWR net1113 sky130_fd_sc_hd__dlygate4sd3_1
X_6068_ _1512_ _1635_ _2658_ _2536_ VGND VGND VPWR VPWR _2804_ sky130_fd_sc_hd__a31o_1
Xhold1055 regfile.registers\[10\]\[22\] VGND VGND VPWR VPWR net1135 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_84_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1044 regfile.registers\[21\]\[30\] VGND VGND VPWR VPWR net1124 sky130_fd_sc_hd__dlygate4sd3_1
X_5019_ regfile.registers\[0\]\[21\] regfile.registers\[1\]\[21\] regfile.registers\[2\]\[21\]
+ regfile.registers\[3\]\[21\] _1720_ _1723_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux4_1
XFILLER_0_95_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8709_ clknet_leaf_64_CLK _0893_ VGND VGND VPWR VPWR regfile.registers\[15\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_52_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_125_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_57_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5370_ regfile.registers\[16\]\[14\] regfile.registers\[17\]\[14\] regfile.registers\[18\]\[14\]
+ regfile.registers\[19\]\[14\] _1674_ _1691_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4321_ _1071_ _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__nand2_1
X_7040_ _3442_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8991_ clknet_leaf_78_CLK _0151_ VGND VGND VPWR VPWR regfile.registers\[29\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_66_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7942_ _3132_ net517 _3927_ VGND VGND VPWR VPWR _3937_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7873_ _3900_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__clkbuf_1
X_6824_ _3069_ net975 _3325_ VGND VGND VPWR VPWR _3328_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6755_ _3291_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9543_ clknet_leaf_59_CLK _0703_ VGND VGND VPWR VPWR regfile.registers\[11\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5706_ _1128_ _2458_ _2421_ VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9474_ clknet_leaf_85_CLK _0634_ VGND VGND VPWR VPWR regfile.registers\[16\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_8425_ _4193_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__clkbuf_1
X_6686_ _3067_ net825 _3253_ VGND VGND VPWR VPWR _3255_ sky130_fd_sc_hd__mux2_1
XFILLER_0_116_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5637_ _1799_ _1732_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8356_ net286 _3536_ _4155_ VGND VGND VPWR VPWR _4157_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5568_ _1842_ _2323_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4519_ _1273_ _1274_ _1211_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__mux2_1
X_8287_ _4120_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__clkbuf_1
Xhold152 regfile.registers\[0\]\[30\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 regfile.registers\[17\]\[8\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
X_7307_ _3600_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
Xhold130 regfile.registers\[1\]\[11\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 regfile.registers\[3\]\[23\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
X_5499_ _2254_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__buf_2
X_7238_ net208 _3510_ _3553_ VGND VGND VPWR VPWR _3563_ sky130_fd_sc_hd__mux2_1
Xhold174 regfile.registers\[8\]\[13\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 regfile.registers\[6\]\[4\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold196 regfile.registers\[9\]\[23\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7169_ net21 VGND VGND VPWR VPWR _3521_ sky130_fd_sc_hd__buf_2
XFILLER_0_96_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4870_ regfile.registers\[8\]\[18\] regfile.registers\[9\]\[18\] regfile.registers\[10\]\[18\]
+ regfile.registers\[11\]\[18\] _1192_ _1195_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__mux4_1
XFILLER_0_129_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6540_ _3175_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6471_ _3136_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5422_ _1877_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9190_ clknet_leaf_69_CLK _0350_ VGND VGND VPWR VPWR regfile.registers\[30\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_8210_ _4079_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_97_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5353_ regfile.registers\[24\]\[15\] regfile.registers\[25\]\[15\] regfile.registers\[26\]\[15\]
+ regfile.registers\[27\]\[15\] _1782_ _1680_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__mux4_1
X_8141_ net440 _3525_ _4036_ VGND VGND VPWR VPWR _4043_ sky130_fd_sc_hd__mux2_1
X_4304_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5284_ _2039_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__buf_2
X_8072_ _4006_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__clkbuf_1
X_7023_ _3433_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_74_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8974_ clknet_leaf_5_CLK _0134_ VGND VGND VPWR VPWR regfile.registers\[7\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7925_ _3928_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__clkbuf_1
X_7856_ net256 _3512_ _3891_ VGND VGND VPWR VPWR _3892_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6807_ _3052_ net869 _3314_ VGND VGND VPWR VPWR _3319_ sky130_fd_sc_hd__mux2_1
X_4999_ _1639_ _1754_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__and2b_1
X_9526_ clknet_leaf_49_CLK _0686_ VGND VGND VPWR VPWR regfile.registers\[12\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_83_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7787_ _3843_ VGND VGND VPWR VPWR _3855_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_61_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6738_ _3282_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9457_ clknet_leaf_19_CLK _0617_ VGND VGND VPWR VPWR regfile.registers\[13\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_6669_ _3050_ net1012 _3242_ VGND VGND VPWR VPWR _3246_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9388_ clknet_leaf_107_CLK _0548_ VGND VGND VPWR VPWR regfile.registers\[24\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_8408_ _4184_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__clkbuf_1
X_8339_ net421 _3519_ _4144_ VGND VGND VPWR VPWR _4148_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_92_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_122_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5971_ _2661_ _2688_ _2687_ VGND VGND VPWR VPWR _2713_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_84_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8690_ clknet_3_6__leaf_CLK _0874_ VGND VGND VPWR VPWR regfile.registers\[0\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_7710_ _3814_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__clkbuf_1
X_4922_ _1677_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__buf_4
XFILLER_0_75_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7641_ net322 _3502_ _3772_ VGND VGND VPWR VPWR _3778_ sky130_fd_sc_hd__mux2_1
X_4853_ _1605_ _1608_ _1187_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4784_ _1538_ _1539_ _1107_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__mux2_1
X_7572_ _3741_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6523_ _3043_ net1106 _3166_ VGND VGND VPWR VPWR _3167_ sky130_fd_sc_hd__mux2_1
X_9311_ clknet_leaf_79_CLK _0471_ VGND VGND VPWR VPWR regfile.registers\[21\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9242_ clknet_leaf_31_CLK _0402_ VGND VGND VPWR VPWR regfile.registers\[9\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_6454_ net453 _3124_ _3114_ VGND VGND VPWR VPWR _3125_ sky130_fd_sc_hd__mux2_1
Xclkload50 clknet_leaf_35_CLK VGND VGND VPWR VPWR clkload50/Y sky130_fd_sc_hd__clkinvlp_2
Xclkload61 clknet_leaf_49_CLK VGND VGND VPWR VPWR clkload61/Y sky130_fd_sc_hd__bufinv_16
X_5405_ _2144_ _2160_ _1800_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_70_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload94 clknet_leaf_53_CLK VGND VGND VPWR VPWR clkload94/Y sky130_fd_sc_hd__clkinv_4
X_9173_ clknet_leaf_32_CLK _0333_ VGND VGND VPWR VPWR regfile.registers\[2\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_6385_ net34 VGND VGND VPWR VPWR _3077_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload72 clknet_leaf_93_CLK VGND VGND VPWR VPWR clkload72/Y sky130_fd_sc_hd__bufinv_16
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload83 clknet_leaf_74_CLK VGND VGND VPWR VPWR clkload83/Y sky130_fd_sc_hd__inv_8
X_8124_ net833 _3508_ _4025_ VGND VGND VPWR VPWR _4034_ sky130_fd_sc_hd__mux2_1
X_5336_ net3 _2091_ _1655_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__o21a_1
X_5267_ _2021_ _2022_ _1745_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__mux2_1
X_8055_ _3997_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7006_ net463 _3116_ _3423_ VGND VGND VPWR VPWR _3425_ sky130_fd_sc_hd__mux2_1
X_5198_ regfile.registers\[8\]\[28\] regfile.registers\[9\]\[28\] regfile.registers\[10\]\[28\]
+ regfile.registers\[11\]\[28\] _1896_ _1898_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__mux4_1
XFILLER_0_97_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8957_ clknet_leaf_12_CLK _0117_ VGND VGND VPWR VPWR regfile.registers\[3\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7908_ _3919_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__clkbuf_1
X_8888_ clknet_leaf_14_CLK _0048_ VGND VGND VPWR VPWR regfile.registers\[4\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_104_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7839_ net871 _3496_ _3880_ VGND VGND VPWR VPWR _3883_ sky130_fd_sc_hd__mux2_1
XFILLER_0_108_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload0 clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clkload0/X sky130_fd_sc_hd__clkbuf_8
X_9509_ clknet_leaf_65_CLK _0669_ VGND VGND VPWR VPWR regfile.registers\[12\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold707 regfile.registers\[7\]\[7\] VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlygate4sd3_1
Xhold718 regfile.registers\[21\]\[4\] VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold729 regfile.registers\[13\]\[21\] VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__dlygate4sd3_1
X_6170_ _2621_ _2894_ _2900_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__o21a_1
XFILLER_0_110_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5121_ _1145_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5052_ regfile.registers\[28\]\[18\] regfile.registers\[29\]\[18\] regfile.registers\[30\]\[18\]
+ regfile.registers\[31\]\[18\] _1734_ _1735_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__mux4_1
X_8811_ clknet_leaf_98_CLK _0995_ VGND VGND VPWR VPWR regfile.registers\[6\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_8742_ clknet_leaf_56_CLK _0926_ VGND VGND VPWR VPWR regfile.registers\[8\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_5954_ _2345_ _2349_ VGND VGND VPWR VPWR _2697_ sky130_fd_sc_hd__and2_1
XFILLER_0_62_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4905_ _1639_ _1660_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__nor2_1
X_5885_ _2630_ net1139 _2593_ _2594_ _2595_ VGND VGND VPWR VPWR _2631_ sky130_fd_sc_hd__o41a_1
X_8673_ clknet_leaf_65_CLK _0857_ VGND VGND VPWR VPWR regfile.registers\[0\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7624_ _3768_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4836_ _1588_ _1589_ _1590_ _1591_ _1287_ _1078_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7555_ _3083_ net685 _3722_ VGND VGND VPWR VPWR _3732_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4767_ _1047_ _1522_ _1037_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6506_ _3027_ net1078 _3155_ VGND VGND VPWR VPWR _3158_ sky130_fd_sc_hd__mux2_1
X_7486_ _3695_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
X_4698_ _1452_ _1453_ _1036_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6437_ net17 VGND VGND VPWR VPWR _3113_ sky130_fd_sc_hd__buf_2
X_9225_ clknet_leaf_99_CLK _0385_ VGND VGND VPWR VPWR regfile.registers\[9\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6368_ _3064_ net622 _3065_ VGND VGND VPWR VPWR _3066_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9156_ clknet_leaf_64_CLK _0316_ VGND VGND VPWR VPWR regfile.registers\[2\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_8107_ _4024_ VGND VGND VPWR VPWR _4025_ sky130_fd_sc_hd__clkbuf_8
X_5319_ net3 _2074_ _1655_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__a21o_1
X_6299_ net304 _3017_ _3007_ VGND VGND VPWR VPWR _3018_ sky130_fd_sc_hd__mux2_1
X_9087_ clknet_leaf_80_CLK _0247_ VGND VGND VPWR VPWR regfile.registers\[27\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold45 regfile.registers\[2\]\[24\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 regfile.registers\[7\]\[30\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
X_8038_ _3987_ _3192_ VGND VGND VPWR VPWR _3988_ sky130_fd_sc_hd__nor2_4
Xhold34 regfile.registers\[9\]\[5\] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold67 regfile.registers\[5\]\[10\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 regfile.registers\[1\]\[12\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 regfile.registers\[7\]\[0\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_106_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_106_CLK
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_107_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5670_ _2423_ _2143_ _1147_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4621_ regfile.registers\[0\]\[24\] regfile.registers\[1\]\[24\] regfile.registers\[2\]\[24\]
+ regfile.registers\[3\]\[24\] _1360_ _1361_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__mux4_1
X_7340_ _3073_ net757 _3613_ VGND VGND VPWR VPWR _3618_ sky130_fd_sc_hd__mux2_1
XFILLER_0_108_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4552_ regfile.registers\[8\]\[27\] regfile.registers\[9\]\[27\] regfile.registers\[10\]\[27\]
+ regfile.registers\[11\]\[27\] _1267_ _1268_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__mux4_1
XFILLER_0_123_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7271_ _3580_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
Xhold504 regfile.registers\[29\]\[20\] VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__dlygate4sd3_1
X_4483_ _1215_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__clkbuf_8
Xhold515 regfile.registers\[1\]\[13\] VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__dlygate4sd3_1
Xhold526 regfile.registers\[7\]\[11\] VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6222_ net81 _2741_ _2930_ VGND VGND VPWR VPWR _2949_ sky130_fd_sc_hd__o21ba_1
X_9010_ clknet_leaf_49_CLK _0170_ VGND VGND VPWR VPWR regfile.registers\[29\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_92_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold548 regfile.registers\[15\]\[9\] VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__dlygate4sd3_1
Xhold559 regfile.registers\[28\]\[8\] VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold537 regfile.registers\[0\]\[6\] VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6153_ _2879_ _2883_ _2877_ VGND VGND VPWR VPWR _2885_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_57_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6084_ _2795_ _2798_ _2803_ _2819_ _2408_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__o32a_1
X_5104_ _1168_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__or2_1
X_5035_ _1686_ _1790_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6986_ _3414_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_8725_ clknet_leaf_30_CLK _0909_ VGND VGND VPWR VPWR regfile.registers\[15\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_5937_ _2491_ _2591_ _2680_ VGND VGND VPWR VPWR _2681_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8656_ clknet_leaf_8_CLK _0840_ VGND VGND VPWR VPWR regfile.registers\[22\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_7607_ _3067_ net447 _3758_ VGND VGND VPWR VPWR _3760_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5868_ _1528_ _2594_ _2593_ net1140 _2595_ VGND VGND VPWR VPWR _2615_ sky130_fd_sc_hd__o41a_1
XFILLER_0_63_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5799_ _2546_ _2548_ _2501_ VGND VGND VPWR VPWR _2549_ sky130_fd_sc_hd__mux2_1
X_8587_ clknet_leaf_104_CLK _0771_ VGND VGND VPWR VPWR regfile.registers\[23\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4819_ regfile.registers\[28\]\[16\] regfile.registers\[29\]\[16\] regfile.registers\[30\]\[16\]
+ regfile.registers\[31\]\[16\] _1291_ _1174_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__mux4_1
X_7538_ _3723_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7469_ _3064_ net598 _3686_ VGND VGND VPWR VPWR _3687_ sky130_fd_sc_hd__mux2_1
XFILLER_0_114_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9208_ clknet_leaf_20_CLK _0368_ VGND VGND VPWR VPWR regfile.registers\[30\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput57 net57 VGND VGND VPWR VPWR ALUResult[17] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR ALUResult[27] sky130_fd_sc_hd__clkbuf_4
X_9139_ clknet_leaf_27_CLK _0299_ VGND VGND VPWR VPWR regfile.registers\[28\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput79 net79 VGND VGND VPWR VPWR ALUResult[8] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_112_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6840_ _3085_ net774 _3302_ VGND VGND VPWR VPWR _3336_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6771_ _3299_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__clkbuf_1
X_5722_ _2472_ _2474_ _2251_ VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8510_ net274 net39 _4204_ VGND VGND VPWR VPWR _4238_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9490_ clknet_leaf_47_CLK _0650_ VGND VGND VPWR VPWR regfile.registers\[16\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8441_ _4201_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__clkbuf_1
X_5653_ _2333_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__buf_2
XFILLER_0_45_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4604_ _1351_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__buf_4
X_8372_ net681 _3484_ _4155_ VGND VGND VPWR VPWR _4165_ sky130_fd_sc_hd__mux2_1
X_5584_ _1799_ _2098_ _2338_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold301 regfile.registers\[2\]\[28\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
X_4535_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7323_ _3056_ net216 _3602_ VGND VGND VPWR VPWR _3609_ sky130_fd_sc_hd__mux2_1
Xhold334 regfile.registers\[8\]\[25\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold323 regfile.registers\[5\]\[19\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
Xhold312 regfile.registers\[6\]\[3\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
Xhold367 regfile.registers\[28\]\[21\] VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold356 regfile.registers\[3\]\[26\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd3_1
Xhold345 regfile.registers\[7\]\[19\] VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd3_1
X_4466_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__buf_4
X_7254_ _3571_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
Xhold378 regfile.registers\[13\]\[15\] VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__dlygate4sd3_1
X_6205_ _1958_ _2931_ VGND VGND VPWR VPWR _2933_ sky130_fd_sc_hd__and2_1
X_7185_ net870 _3531_ _3513_ VGND VGND VPWR VPWR _3532_ sky130_fd_sc_hd__mux2_1
Xhold389 regfile.registers\[7\]\[2\] VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__dlygate4sd3_1
X_4397_ _1088_ _1152_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__nand2_1
X_6136_ _2254_ _2801_ _2867_ _2336_ VGND VGND VPWR VPWR _2868_ sky130_fd_sc_hd__o22a_1
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1012 regfile.registers\[14\]\[28\] VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1001 regfile.registers\[3\]\[22\] VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1023 regfile.registers\[23\]\[13\] VGND VGND VPWR VPWR net1103 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6067_ _2799_ _2731_ _2802_ _2496_ VGND VGND VPWR VPWR _2803_ sky130_fd_sc_hd__a22o_1
XFILLER_0_84_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold1034 regfile.registers\[26\]\[19\] VGND VGND VPWR VPWR net1114 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1045 regfile.registers\[29\]\[11\] VGND VGND VPWR VPWR net1125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1056 regfile.registers\[4\]\[5\] VGND VGND VPWR VPWR net1136 sky130_fd_sc_hd__dlygate4sd3_1
X_5018_ regfile.registers\[4\]\[21\] regfile.registers\[5\]\[21\] regfile.registers\[6\]\[21\]
+ regfile.registers\[7\]\[21\] _1705_ _1708_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__mux4_1
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6969_ net448 _3002_ _3398_ VGND VGND VPWR VPWR _3405_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8708_ clknet_leaf_91_CLK _0892_ VGND VGND VPWR VPWR regfile.registers\[15\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_52_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8639_ clknet_leaf_80_CLK _0823_ VGND VGND VPWR VPWR regfile.registers\[22\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold890 regfile.registers\[21\]\[31\] VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_103_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_112_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4320_ _1074_ _1075_ _1048_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8990_ clknet_leaf_72_CLK _0150_ VGND VGND VPWR VPWR regfile.registers\[29\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_121_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7941_ _3936_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__clkbuf_1
X_7872_ net374 _3529_ _3891_ VGND VGND VPWR VPWR _3900_ sky130_fd_sc_hd__mux2_1
X_6823_ _3327_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6754_ net526 _3137_ _3289_ VGND VGND VPWR VPWR _3291_ sky130_fd_sc_hd__mux2_1
X_9542_ clknet_leaf_56_CLK _0702_ VGND VGND VPWR VPWR regfile.registers\[11\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_95_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_95_CLK sky130_fd_sc_hd__clkbuf_8
X_5705_ _2455_ _2457_ _1146_ VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__mux2_1
X_6685_ _3254_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__clkbuf_1
X_9473_ clknet_leaf_83_CLK _0633_ VGND VGND VPWR VPWR regfile.registers\[16\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8424_ net235 _3536_ _4191_ VGND VGND VPWR VPWR _4193_ sky130_fd_sc_hd__mux2_1
XFILLER_0_116_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5636_ _1667_ _2034_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8355_ _4156_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__clkbuf_1
X_5567_ _1728_ _2314_ _2318_ _2322_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold142 regfile.registers\[16\]\[23\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
X_4518_ regfile.registers\[0\]\[21\] regfile.registers\[1\]\[21\] regfile.registers\[2\]\[21\]
+ regfile.registers\[3\]\[21\] _1201_ _1203_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__mux4_1
X_5498_ _2039_ _1126_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__or2_2
Xhold120 regfile.registers\[1\]\[29\] VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
X_8286_ _3134_ net348 _4119_ VGND VGND VPWR VPWR _4120_ sky130_fd_sc_hd__mux2_1
Xhold131 regfile.registers\[25\]\[26\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 regfile.registers\[8\]\[9\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
X_7306_ _3039_ net238 _3591_ VGND VGND VPWR VPWR _3600_ sky130_fd_sc_hd__mux2_1
Xhold186 regfile.registers\[5\]\[28\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 regfile.registers\[12\]\[29\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 regfile.registers\[3\]\[31\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
X_7237_ _3562_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
X_4449_ _1078_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_129_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold197 regfile.registers\[5\]\[2\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7168_ _3520_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_6119_ _1446_ _2741_ _2836_ VGND VGND VPWR VPWR _2852_ sky130_fd_sc_hd__o21ai_1
X_7099_ _3474_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_86_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_86_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_107_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_10_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_10_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_77_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_77_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_54_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6470_ net257 _3134_ _3135_ VGND VGND VPWR VPWR _3136_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5421_ _2161_ _2176_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__and2b_1
XFILLER_0_70_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5352_ regfile.registers\[28\]\[15\] regfile.registers\[29\]\[15\] regfile.registers\[30\]\[15\]
+ regfile.registers\[31\]\[15\] _1782_ _1680_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8140_ _4042_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__clkbuf_1
X_4303_ _1039_ _1025_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__o21ai_2
X_8071_ net474 _3523_ _4000_ VGND VGND VPWR VPWR _4006_ sky130_fd_sc_hd__mux2_1
X_7022_ net605 _3132_ _3423_ VGND VGND VPWR VPWR _3433_ sky130_fd_sc_hd__mux2_1
X_5283_ _1171_ _1094_ _1098_ _1102_ _1109_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8973_ clknet_leaf_94_CLK _0133_ VGND VGND VPWR VPWR regfile.registers\[7\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7924_ _3113_ net1060 _3927_ VGND VGND VPWR VPWR _3928_ sky130_fd_sc_hd__mux2_1
X_7855_ _3879_ VGND VGND VPWR VPWR _3891_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_92_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_68_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_68_CLK sky130_fd_sc_hd__clkbuf_8
X_6806_ _3318_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9525_ clknet_leaf_29_CLK _0685_ VGND VGND VPWR VPWR regfile.registers\[12\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_4998_ _1671_ _1744_ _1749_ _1753_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__o22a_2
X_7786_ _3854_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6737_ net254 _3120_ _3278_ VGND VGND VPWR VPWR _3282_ sky130_fd_sc_hd__mux2_1
X_6668_ _3245_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__clkbuf_1
X_9456_ clknet_leaf_6_CLK _0616_ VGND VGND VPWR VPWR regfile.registers\[13\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_5619_ _2255_ _2364_ _2371_ _2373_ VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__o211a_1
X_9387_ clknet_leaf_103_CLK _0547_ VGND VGND VPWR VPWR regfile.registers\[24\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_8407_ net572 _3519_ _4180_ VGND VGND VPWR VPWR _4184_ sky130_fd_sc_hd__mux2_1
X_6599_ _3208_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8338_ _4147_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_57_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8269_ _3118_ net811 _4108_ VGND VGND VPWR VPWR _4111_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_59_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_59_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_83_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5970_ _2140_ _2711_ VGND VGND VPWR VPWR _2712_ sky130_fd_sc_hd__xnor2_2
X_4921_ net2 VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__clkbuf_4
X_4852_ _1606_ _1607_ _1178_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__mux2_1
X_7640_ _3777_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_99_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4783_ regfile.registers\[0\]\[9\] regfile.registers\[1\]\[9\] regfile.registers\[2\]\[9\]
+ regfile.registers\[3\]\[9\] _1149_ _1028_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__mux4_1
XFILLER_0_62_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7571_ _3031_ net907 _3736_ VGND VGND VPWR VPWR _3741_ sky130_fd_sc_hd__mux2_1
X_6522_ _3154_ VGND VGND VPWR VPWR _3166_ sky130_fd_sc_hd__buf_6
XFILLER_0_28_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9310_ clknet_leaf_71_CLK _0470_ VGND VGND VPWR VPWR regfile.registers\[21\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_9241_ clknet_leaf_49_CLK _0401_ VGND VGND VPWR VPWR regfile.registers\[9\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6453_ net22 VGND VGND VPWR VPWR _3124_ sky130_fd_sc_hd__buf_2
Xclkload51 clknet_leaf_36_CLK VGND VGND VPWR VPWR clkload51/Y sky130_fd_sc_hd__clkinv_1
Xclkload62 clknet_leaf_51_CLK VGND VGND VPWR VPWR clkload62/Y sky130_fd_sc_hd__clkinv_4
Xclkload40 clknet_leaf_27_CLK VGND VGND VPWR VPWR clkload40/Y sky130_fd_sc_hd__clkinvlp_2
X_9172_ clknet_leaf_15_CLK _0332_ VGND VGND VPWR VPWR regfile.registers\[2\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5404_ _1640_ _2151_ _2159_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__o21a_2
X_6384_ _3076_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__clkbuf_1
Xclkload95 clknet_leaf_54_CLK VGND VGND VPWR VPWR clkload95/Y sky130_fd_sc_hd__inv_6
XFILLER_0_113_577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload84 clknet_leaf_75_CLK VGND VGND VPWR VPWR clkload84/Y sky130_fd_sc_hd__inv_6
Xclkload73 clknet_leaf_95_CLK VGND VGND VPWR VPWR clkload73/Y sky130_fd_sc_hd__clkinvlp_4
X_8123_ _4033_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__clkbuf_1
X_5335_ regfile.registers\[0\]\[1\] regfile.registers\[1\]\[1\] regfile.registers\[2\]\[1\]
+ regfile.registers\[3\]\[1\] _1701_ _1677_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__mux4_1
X_5266_ regfile.registers\[24\]\[24\] regfile.registers\[25\]\[24\] regfile.registers\[26\]\[24\]
+ regfile.registers\[27\]\[24\] _1918_ _1919_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__mux4_1
X_8054_ net412 _3506_ _3989_ VGND VGND VPWR VPWR _3997_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7005_ _3424_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_5197_ _1901_ _1952_ _1766_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_39_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8956_ clknet_leaf_42_CLK _0116_ VGND VGND VPWR VPWR regfile.registers\[3\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7907_ _3097_ net1105 _3916_ VGND VGND VPWR VPWR _3919_ sky130_fd_sc_hd__mux2_1
X_8887_ clknet_leaf_52_CLK _0047_ VGND VGND VPWR VPWR regfile.registers\[4\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7838_ _3882_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7769_ net148 _3494_ _3844_ VGND VGND VPWR VPWR _3846_ sky130_fd_sc_hd__mux2_1
XFILLER_0_80_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9508_ clknet_leaf_90_CLK _0668_ VGND VGND VPWR VPWR regfile.registers\[12\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkload1 clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_8
XFILLER_0_46_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9439_ clknet_leaf_81_CLK _0599_ VGND VGND VPWR VPWR regfile.registers\[13\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold719 regfile.registers\[29\]\[1\] VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold708 regfile.registers\[12\]\[7\] VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_94_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5120_ _1860_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__nand2_1
X_5051_ _1805_ _1806_ _1739_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__mux2_1
X_8810_ clknet_leaf_0_CLK _0994_ VGND VGND VPWR VPWR regfile.registers\[6\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_8741_ clknet_leaf_63_CLK _0925_ VGND VGND VPWR VPWR regfile.registers\[8\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5953_ _2340_ _2608_ _1879_ VGND VGND VPWR VPWR _2696_ sky130_fd_sc_hd__mux2_1
X_5884_ _1528_ _1542_ VGND VGND VPWR VPWR _2630_ sky130_fd_sc_hd__or2b_1
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8672_ clknet_leaf_77_CLK _0856_ VGND VGND VPWR VPWR regfile.registers\[0\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_4904_ _1640_ _1650_ _1654_ _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_118_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7623_ _3083_ net858 _3758_ VGND VGND VPWR VPWR _3768_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4835_ regfile.registers\[20\]\[17\] regfile.registers\[21\]\[17\] regfile.registers\[22\]\[17\]
+ regfile.registers\[23\]\[17\] _1291_ _1194_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__mux4_1
XFILLER_0_118_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7554_ _3731_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
X_4766_ regfile.registers\[8\]\[8\] regfile.registers\[9\]\[8\] regfile.registers\[10\]\[8\]
+ regfile.registers\[11\]\[8\] _1149_ _1028_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__mux4_1
X_6505_ _3157_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__clkbuf_1
X_7485_ _3081_ net1007 _3686_ VGND VGND VPWR VPWR _3695_ sky130_fd_sc_hd__mux2_1
X_4697_ regfile.registers\[24\]\[12\] regfile.registers\[25\]\[12\] regfile.registers\[26\]\[12\]
+ regfile.registers\[27\]\[12\] net95 _1221_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__mux4_1
X_6436_ _3112_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__clkbuf_1
X_9224_ clknet_leaf_88_CLK _0384_ VGND VGND VPWR VPWR regfile.registers\[9\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6367_ _3022_ VGND VGND VPWR VPWR _3065_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_54_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9155_ clknet_leaf_89_CLK _0315_ VGND VGND VPWR VPWR regfile.registers\[2\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_8106_ _3192_ _3662_ VGND VGND VPWR VPWR _4024_ sky130_fd_sc_hd__nor2b_4
X_5318_ regfile.registers\[12\]\[2\] regfile.registers\[13\]\[2\] regfile.registers\[14\]\[2\]
+ regfile.registers\[15\]\[2\] _1673_ _1690_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__mux4_1
X_6298_ net40 VGND VGND VPWR VPWR _3017_ sky130_fd_sc_hd__buf_2
X_9086_ clknet_leaf_73_CLK _0246_ VGND VGND VPWR VPWR regfile.registers\[27\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_5249_ _2003_ _2004_ _1726_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__mux2_1
Xhold46 regfile.registers\[3\]\[24\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 regfile.registers\[5\]\[24\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
X_8037_ _3020_ VGND VGND VPWR VPWR _3987_ sky130_fd_sc_hd__inv_2
Xhold57 regfile.registers\[20\]\[10\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 regfile.registers\[9\]\[11\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 regfile.registers\[9\]\[1\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8939_ clknet_leaf_97_CLK _0099_ VGND VGND VPWR VPWR regfile.registers\[3\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_117_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4620_ regfile.registers\[4\]\[24\] regfile.registers\[5\]\[24\] regfile.registers\[6\]\[24\]
+ regfile.registers\[7\]\[24\] _1360_ _1361_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_751 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4551_ regfile.registers\[12\]\[27\] regfile.registers\[13\]\[27\] regfile.registers\[14\]\[27\]
+ regfile.registers\[15\]\[27\] _1267_ _1268_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__mux4_1
XFILLER_0_80_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7270_ net192 _3542_ _3575_ VGND VGND VPWR VPWR _3580_ sky130_fd_sc_hd__mux2_1
X_4482_ _1217_ _1237_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__nand2_2
Xhold516 regfile.registers\[30\]\[8\] VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__dlygate4sd3_1
Xhold527 regfile.registers\[24\]\[3\] VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold505 regfile.registers\[0\]\[0\] VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__dlygate4sd3_1
X_6221_ _2421_ _2941_ _2943_ _2948_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__o22a_1
Xhold538 regfile.registers\[13\]\[27\] VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__dlygate4sd3_1
Xhold549 regfile.registers\[14\]\[0\] VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__dlygate4sd3_1
X_6152_ _2877_ _2879_ _2883_ VGND VGND VPWR VPWR _2884_ sky130_fd_sc_hd__and3_1
X_5103_ _1842_ _1858_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6083_ _2808_ _2818_ VGND VGND VPWR VPWR _2819_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5034_ regfile.registers\[8\]\[20\] regfile.registers\[9\]\[20\] regfile.registers\[10\]\[20\]
+ regfile.registers\[11\]\[20\] _1719_ _1722_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__mux4_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6985_ net452 _3095_ _3412_ VGND VGND VPWR VPWR _3414_ sky130_fd_sc_hd__mux2_1
X_5936_ _2486_ _2588_ _2679_ _1962_ _2333_ VGND VGND VPWR VPWR _2680_ sky130_fd_sc_hd__o221a_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8724_ clknet_leaf_23_CLK _0908_ VGND VGND VPWR VPWR regfile.registers\[15\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8655_ clknet_leaf_2_CLK _0839_ VGND VGND VPWR VPWR regfile.registers\[22\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7606_ _3759_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
X_5867_ _1087_ _2613_ VGND VGND VPWR VPWR _2614_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5798_ _2499_ _2547_ _2347_ VGND VGND VPWR VPWR _2548_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4818_ regfile.registers\[24\]\[16\] regfile.registers\[25\]\[16\] regfile.registers\[26\]\[16\]
+ regfile.registers\[27\]\[16\] _1291_ _1194_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__mux4_1
X_8586_ clknet_leaf_107_CLK _0770_ VGND VGND VPWR VPWR regfile.registers\[23\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7537_ _3064_ net708 _3722_ VGND VGND VPWR VPWR _3723_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4749_ _1503_ _1504_ _1190_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__mux2_1
XFILLER_0_121_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7468_ _3663_ VGND VGND VPWR VPWR _3686_ sky130_fd_sc_hd__clkbuf_8
X_9207_ clknet_leaf_34_CLK _0367_ VGND VGND VPWR VPWR regfile.registers\[30\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_6419_ net42 VGND VGND VPWR VPWR _3101_ sky130_fd_sc_hd__buf_2
Xoutput58 net58 VGND VGND VPWR VPWR ALUResult[18] sky130_fd_sc_hd__clkbuf_4
X_7399_ _3626_ VGND VGND VPWR VPWR _3649_ sky130_fd_sc_hd__buf_6
Xoutput69 net69 VGND VGND VPWR VPWR ALUResult[28] sky130_fd_sc_hd__clkbuf_4
X_9138_ clknet_leaf_46_CLK _0298_ VGND VGND VPWR VPWR regfile.registers\[28\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_112_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9069_ clknet_leaf_97_CLK _0229_ VGND VGND VPWR VPWR regfile.registers\[26\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6770_ net438 _3013_ _3289_ VGND VGND VPWR VPWR _3299_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5721_ _2473_ _2385_ _1146_ VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8440_ net255 net37 _4191_ VGND VGND VPWR VPWR _4201_ sky130_fd_sc_hd__mux2_1
X_5652_ _1666_ _2406_ VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4603_ _1355_ _1358_ _1214_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8371_ _4164_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__clkbuf_1
X_5583_ _1167_ _1661_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold302 regfile.registers\[12\]\[20\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
X_7322_ _3608_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
X_4534_ _1065_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__buf_6
XFILLER_0_41_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold313 regfile.registers\[13\]\[19\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
Xhold324 regfile.registers\[26\]\[8\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold335 regfile.registers\[12\]\[4\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
Xhold357 regfile.registers\[9\]\[21\] VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold368 regfile.registers\[5\]\[26\] VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__dlygate4sd3_1
Xhold346 regfile.registers\[10\]\[19\] VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlygate4sd3_1
X_7253_ net441 _3525_ _3564_ VGND VGND VPWR VPWR _3571_ sky130_fd_sc_hd__mux2_1
X_4465_ _1053_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__buf_4
X_6204_ _1958_ _2931_ VGND VGND VPWR VPWR _2932_ sky130_fd_sc_hd__nor2_1
X_7184_ net26 VGND VGND VPWR VPWR _3531_ sky130_fd_sc_hd__buf_2
Xhold379 regfile.registers\[2\]\[14\] VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd3_1
X_4396_ _1150_ _1151_ _1035_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__mux2_1
X_6135_ _2847_ _2866_ _1147_ VGND VGND VPWR VPWR _2867_ sky130_fd_sc_hd__mux2_1
X_6066_ _2735_ _2801_ _2252_ VGND VGND VPWR VPWR _2802_ sky130_fd_sc_hd__mux2_1
Xhold1024 regfile.registers\[2\]\[19\] VGND VGND VPWR VPWR net1104 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1002 regfile.registers\[27\]\[2\] VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1013 regfile.registers\[30\]\[18\] VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__dlygate4sd3_1
X_5017_ _1717_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__buf_4
Xhold1046 regfile.registers\[18\]\[31\] VGND VGND VPWR VPWR net1126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1035 regfile.registers\[26\]\[18\] VGND VGND VPWR VPWR net1115 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6968_ _3404_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8707_ clknet_leaf_83_CLK _0891_ VGND VGND VPWR VPWR regfile.registers\[15\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6899_ net179 _3145_ _3362_ VGND VGND VPWR VPWR _3368_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5919_ _2661_ _2662_ VGND VGND VPWR VPWR _2663_ sky130_fd_sc_hd__nand2_2
XFILLER_0_76_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8638_ clknet_leaf_71_CLK _0822_ VGND VGND VPWR VPWR regfile.registers\[22\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_8569_ clknet_leaf_38_CLK _0753_ VGND VGND VPWR VPWR regfile.registers\[10\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_106_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_114_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold880 regfile.registers\[27\]\[8\] VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold891 regfile.registers\[31\]\[10\] VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7940_ _3130_ net237 _3927_ VGND VGND VPWR VPWR _3936_ sky130_fd_sc_hd__mux2_1
X_7871_ _3899_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6822_ _3067_ net913 _3325_ VGND VGND VPWR VPWR _3327_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6753_ _3290_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__clkbuf_1
X_9541_ clknet_leaf_64_CLK _0701_ VGND VGND VPWR VPWR regfile.registers\[11\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5704_ _2456_ VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__inv_2
X_6684_ _3064_ net1087 _3253_ VGND VGND VPWR VPWR _3254_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9472_ clknet_leaf_77_CLK _0632_ VGND VGND VPWR VPWR regfile.registers\[16\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5635_ _2382_ _2389_ _2251_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__mux2_4
X_8423_ _4192_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8354_ net275 _3533_ _4155_ VGND VGND VPWR VPWR _4156_ sky130_fd_sc_hd__mux2_1
Xhold110 regfile.registers\[6\]\[15\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_14_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5566_ _1696_ _2321_ _1670_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__o21ai_1
Xhold121 regfile.registers\[1\]\[25\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 regfile.registers\[10\]\[25\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
X_4517_ regfile.registers\[4\]\[21\] regfile.registers\[5\]\[21\] regfile.registers\[6\]\[21\]
+ regfile.registers\[7\]\[21\] _1201_ _1203_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux4_1
X_5497_ _2179_ _2250_ _2252_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__mux2_1
Xhold143 regfile.registers\[3\]\[20\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
X_8285_ _4096_ VGND VGND VPWR VPWR _4119_ sky130_fd_sc_hd__clkbuf_8
X_7305_ _3599_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
Xhold165 regfile.registers\[18\]\[23\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
X_4448_ regfile.registers\[8\]\[29\] regfile.registers\[9\]\[29\] regfile.registers\[10\]\[29\]
+ regfile.registers\[11\]\[29\] _1201_ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__mux4_1
X_7236_ net217 _3508_ _3553_ VGND VGND VPWR VPWR _3562_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold176 regfile.registers\[18\]\[10\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 regfile.registers\[18\]\[12\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 regfile.registers\[7\]\[18\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 regfile.registers\[10\]\[14\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4379_ _1131_ _1134_ _1037_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__mux2_2
X_7167_ net1029 _3519_ _3513_ VGND VGND VPWR VPWR _3520_ sky130_fd_sc_hd__mux2_1
X_6118_ _2408_ _2845_ _2846_ _2851_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__o22a_1
X_7098_ net492 _3139_ _3471_ VGND VGND VPWR VPWR _3474_ sky130_fd_sc_hd__mux2_1
X_6049_ _1820_ _2768_ VGND VGND VPWR VPWR _2786_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5420_ _1758_ _2175_ _1800_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_112_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5351_ regfile.registers\[16\]\[15\] regfile.registers\[17\]\[15\] regfile.registers\[18\]\[15\]
+ regfile.registers\[19\]\[15\] _1782_ _1680_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__mux4_1
X_5282_ _1962_ _2037_ _1879_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__mux2_2
X_8070_ _4005_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__clkbuf_1
X_4302_ _1046_ _1051_ _1056_ _1038_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a221o_1
XFILLER_0_49_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7021_ _3432_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8972_ clknet_leaf_0_CLK _0132_ VGND VGND VPWR VPWR regfile.registers\[7\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7923_ _3915_ VGND VGND VPWR VPWR _3927_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_78_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7854_ _3890_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7785_ net444 _3510_ _3844_ VGND VGND VPWR VPWR _3854_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6805_ _3050_ net924 _3314_ VGND VGND VPWR VPWR _3318_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4997_ _1717_ _1752_ _1729_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__a21o_1
X_9524_ clknet_leaf_16_CLK _0684_ VGND VGND VPWR VPWR regfile.registers\[12\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_6736_ _3281_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6667_ _3048_ net797 _3242_ VGND VGND VPWR VPWR _3245_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9455_ clknet_leaf_3_CLK _0615_ VGND VGND VPWR VPWR regfile.registers\[13\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_5618_ _2372_ VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9386_ clknet_leaf_104_CLK _0546_ VGND VGND VPWR VPWR regfile.registers\[24\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_8406_ _4183_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__clkbuf_1
X_6598_ net375 _3118_ _3205_ VGND VGND VPWR VPWR _3208_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8337_ net815 _3517_ _4144_ VGND VGND VPWR VPWR _4147_ sky130_fd_sc_hd__mux2_1
X_5549_ _1728_ _2296_ _2300_ _2304_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__o2bb2a_2
XTAP_TAPCELL_ROW_57_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8268_ _4110_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_70_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7219_ _3552_ VGND VGND VPWR VPWR _3553_ sky130_fd_sc_hd__buf_4
X_8199_ net210 _3515_ _4072_ VGND VGND VPWR VPWR _4074_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_122_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4920_ _1675_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_87_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4851_ regfile.registers\[24\]\[19\] regfile.registers\[25\]\[19\] regfile.registers\[26\]\[19\]
+ regfile.registers\[27\]\[19\] net1150 _1222_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4782_ regfile.registers\[4\]\[9\] regfile.registers\[5\]\[9\] regfile.registers\[6\]\[9\]
+ regfile.registers\[7\]\[9\] _1149_ _1028_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7570_ _3740_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6521_ _3165_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_125_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9240_ clknet_leaf_17_CLK _0400_ VGND VGND VPWR VPWR regfile.registers\[9\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6452_ _3123_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__clkbuf_1
Xclkload41 clknet_leaf_28_CLK VGND VGND VPWR VPWR clkload41/Y sky130_fd_sc_hd__inv_6
XFILLER_0_113_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload52 clknet_leaf_37_CLK VGND VGND VPWR VPWR clkload52/Y sky130_fd_sc_hd__clkinv_1
X_9171_ clknet_leaf_32_CLK _0331_ VGND VGND VPWR VPWR regfile.registers\[2\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkload30 clknet_leaf_104_CLK VGND VGND VPWR VPWR clkload30/Y sky130_fd_sc_hd__clkinv_1
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5403_ _2153_ _2155_ _2158_ net4 net5 VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__a221o_1
X_6383_ _3075_ net678 _3065_ VGND VGND VPWR VPWR _3076_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload96 clknet_leaf_60_CLK VGND VGND VPWR VPWR clkload96/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_3_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload85 clknet_leaf_76_CLK VGND VGND VPWR VPWR clkload85/Y sky130_fd_sc_hd__inv_8
Xclkload74 clknet_leaf_96_CLK VGND VGND VPWR VPWR clkload74/Y sky130_fd_sc_hd__inv_6
Xclkload63 clknet_leaf_64_CLK VGND VGND VPWR VPWR clkload63/Y sky130_fd_sc_hd__clkinvlp_4
X_8122_ net935 _3506_ _4025_ VGND VGND VPWR VPWR _4033_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5334_ _1645_ _2089_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__or2_1
X_5265_ regfile.registers\[28\]\[24\] regfile.registers\[29\]\[24\] regfile.registers\[30\]\[24\]
+ regfile.registers\[31\]\[24\] _1918_ _1919_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__mux4_1
X_8053_ _3996_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__clkbuf_1
X_5196_ regfile.registers\[0\]\[28\] regfile.registers\[1\]\[28\] regfile.registers\[2\]\[28\]
+ regfile.registers\[3\]\[28\] _1896_ _1898_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__mux4_1
X_7004_ net656 _3113_ _3423_ VGND VGND VPWR VPWR _3424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8955_ clknet_leaf_38_CLK _0115_ VGND VGND VPWR VPWR regfile.registers\[3\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_8886_ clknet_leaf_54_CLK _0046_ VGND VGND VPWR VPWR regfile.registers\[4\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7906_ _3918_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7837_ net1030 _3494_ _3880_ VGND VGND VPWR VPWR _3882_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7768_ _3845_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__clkbuf_1
Xclkload2 clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6719_ _3272_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__clkbuf_1
X_9507_ clknet_leaf_82_CLK _0667_ VGND VGND VPWR VPWR regfile.registers\[12\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_7699_ _3019_ net915 _3808_ VGND VGND VPWR VPWR _3809_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9438_ clknet_leaf_73_CLK _0598_ VGND VGND VPWR VPWR regfile.registers\[13\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9369_ clknet_leaf_37_CLK _0529_ VGND VGND VPWR VPWR regfile.registers\[20\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold709 regfile.registers\[12\]\[14\] VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5050_ regfile.registers\[16\]\[18\] regfile.registers\[17\]\[18\] regfile.registers\[18\]\[18\]
+ regfile.registers\[19\]\[18\] _1719_ _1722_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__mux4_1
X_5952_ _2503_ _2693_ _2694_ VGND VGND VPWR VPWR _2695_ sky130_fd_sc_hd__or3_1
X_8740_ clknet_leaf_65_CLK _0924_ VGND VGND VPWR VPWR regfile.registers\[8\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_4903_ _1655_ _1658_ net5 VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5883_ _2427_ _2591_ _2628_ _2504_ VGND VGND VPWR VPWR _2629_ sky130_fd_sc_hd__a211o_1
XFILLER_0_75_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8671_ clknet_leaf_75_CLK _0855_ VGND VGND VPWR VPWR regfile.registers\[0\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7622_ _3767_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
X_4834_ regfile.registers\[16\]\[17\] regfile.registers\[17\]\[17\] regfile.registers\[18\]\[17\]
+ regfile.registers\[19\]\[17\] _1291_ _1194_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_44_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7553_ _3081_ net720 _3722_ VGND VGND VPWR VPWR _3731_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4765_ _1107_ _1520_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6504_ _3025_ net990 _3155_ VGND VGND VPWR VPWR _3157_ sky130_fd_sc_hd__mux2_1
X_7484_ _3694_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_9223_ clknet_leaf_59_CLK _0383_ VGND VGND VPWR VPWR regfile.registers\[9\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4696_ regfile.registers\[28\]\[12\] regfile.registers\[29\]\[12\] regfile.registers\[30\]\[12\]
+ regfile.registers\[31\]\[12\] net95 _1221_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__mux4_1
XFILLER_0_70_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6435_ net231 _3111_ _3093_ VGND VGND VPWR VPWR _3112_ sky130_fd_sc_hd__mux2_1
X_6366_ net28 VGND VGND VPWR VPWR _3064_ sky130_fd_sc_hd__clkbuf_2
X_9154_ clknet_leaf_88_CLK _0314_ VGND VGND VPWR VPWR regfile.registers\[2\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_9085_ clknet_leaf_12_CLK _0245_ VGND VGND VPWR VPWR regfile.registers\[26\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_8105_ _4023_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5317_ _1684_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__and2_1
X_6297_ _3016_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__clkbuf_1
X_8036_ _3986_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__clkbuf_1
Xhold36 regfile.registers\[16\]\[24\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
X_5248_ regfile.registers\[24\]\[25\] regfile.registers\[25\]\[25\] regfile.registers\[26\]\[25\]
+ regfile.registers\[27\]\[25\] _1822_ _1823_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__mux4_1
Xhold47 regfile.registers\[5\]\[11\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
X_5179_ _1889_ _1934_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__and2_1
Xhold69 regfile.registers\[11\]\[8\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 regfile.registers\[5\]\[4\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8938_ clknet_leaf_7_CLK _0098_ VGND VGND VPWR VPWR regfile.registers\[3\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8869_ clknet_leaf_62_CLK _0029_ VGND VGND VPWR VPWR regfile.registers\[4\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_108_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4550_ _1302_ _1305_ _1187_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__mux2_2
XFILLER_0_106_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4481_ _1171_ _1228_ _1236_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__a21oi_4
Xhold506 regfile.registers\[29\]\[30\] VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_80_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold517 regfile.registers\[4\]\[4\] VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__dlygate4sd3_1
X_6220_ _1060_ _2678_ _2737_ _2947_ VGND VGND VPWR VPWR _2948_ sky130_fd_sc_hd__o22a_1
Xhold539 regfile.registers\[16\]\[16\] VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__dlygate4sd3_1
Xhold528 regfile.registers\[29\]\[4\] VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__dlygate4sd3_1
X_6151_ _2812_ _2878_ _2882_ VGND VGND VPWR VPWR _2883_ sky130_fd_sc_hd__o21a_1
X_5102_ _1672_ _1849_ _1853_ _1857_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_0_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6082_ _2812_ _2817_ VGND VGND VPWR VPWR _2818_ sky130_fd_sc_hd__nand2_1
X_5033_ _1785_ _1788_ _1699_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6984_ _3413_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8723_ clknet_leaf_33_CLK _0907_ VGND VGND VPWR VPWR regfile.registers\[15\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5935_ _1666_ _2039_ _2251_ VGND VGND VPWR VPWR _2679_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_101_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5866_ _2340_ _2487_ _2612_ _2530_ VGND VGND VPWR VPWR _2613_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8654_ clknet_leaf_4_CLK _0838_ VGND VGND VPWR VPWR regfile.registers\[22\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_7605_ _3064_ net542 _3758_ VGND VGND VPWR VPWR _3759_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4817_ _1528_ _1558_ _1542_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__and4b_1
XFILLER_0_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5797_ _1669_ _2272_ _2325_ VGND VGND VPWR VPWR _2547_ sky130_fd_sc_hd__o21ai_2
X_8585_ clknet_leaf_103_CLK _0769_ VGND VGND VPWR VPWR regfile.registers\[23\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_7536_ _3699_ VGND VGND VPWR VPWR _3722_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_60_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4748_ regfile.registers\[12\]\[15\] regfile.registers\[13\]\[15\] regfile.registers\[14\]\[15\]
+ regfile.registers\[15\]\[15\] _1201_ _1203_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__mux4_1
X_4679_ regfile.registers\[24\]\[22\] regfile.registers\[25\]\[22\] regfile.registers\[26\]\[22\]
+ regfile.registers\[27\]\[22\] _1182_ _1184_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7467_ _3685_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9206_ clknet_leaf_36_CLK _0366_ VGND VGND VPWR VPWR regfile.registers\[30\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_6418_ _3100_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9137_ clknet_leaf_4_CLK _0297_ VGND VGND VPWR VPWR regfile.registers\[28\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_7398_ _3648_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
Xoutput59 net59 VGND VGND VPWR VPWR ALUResult[19] sky130_fd_sc_hd__buf_2
X_6349_ _3052_ net1022 _3044_ VGND VGND VPWR VPWR _3053_ sky130_fd_sc_hd__mux2_1
X_9068_ clknet_leaf_107_CLK _0228_ VGND VGND VPWR VPWR regfile.registers\[26\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_8019_ _3141_ net949 _3974_ VGND VGND VPWR VPWR _3978_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_47_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5720_ _2381_ VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__inv_2
XFILLER_0_85_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5651_ _2390_ _2405_ _2104_ VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__mux2_1
X_4602_ _1356_ _1357_ _1199_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__mux2_1
X_8370_ net926 _3482_ _4155_ VGND VGND VPWR VPWR _4164_ sky130_fd_sc_hd__mux2_1
X_5582_ _2336_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__clkbuf_4
X_4533_ _1287_ _1288_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__and2_1
X_7321_ _3054_ net569 _3602_ VGND VGND VPWR VPWR _3608_ sky130_fd_sc_hd__mux2_1
XFILLER_0_123_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold325 regfile.registers\[0\]\[25\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold314 regfile.registers\[9\]\[16\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
X_7252_ _3570_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold303 regfile.registers\[2\]\[7\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
X_6203_ net82 _2930_ VGND VGND VPWR VPWR _2931_ sky130_fd_sc_hd__xnor2_1
Xhold358 regfile.registers\[8\]\[29\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__dlygate4sd3_1
Xhold336 regfile.registers\[1\]\[19\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
Xhold347 regfile.registers\[0\]\[8\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd3_1
Xhold369 regfile.registers\[13\]\[16\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__dlygate4sd3_1
X_4464_ net95 VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__buf_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7183_ _3530_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
X_4395_ regfile.registers\[16\]\[0\] regfile.registers\[17\]\[0\] regfile.registers\[18\]\[0\]
+ regfile.registers\[19\]\[0\] net87 _1061_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__mux4_1
X_6134_ _1669_ _1732_ _2035_ VGND VGND VPWR VPWR _2866_ sky130_fd_sc_hd__a21oi_1
X_6065_ _2777_ _2800_ _1147_ VGND VGND VPWR VPWR _2801_ sky130_fd_sc_hd__mux2_1
Xhold1014 regfile.registers\[31\]\[12\] VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1003 regfile.registers\[2\]\[13\] VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__dlygate4sd3_1
X_5016_ _1766_ _1771_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__nand2_1
Xhold1047 regfile.registers\[28\]\[30\] VGND VGND VPWR VPWR net1127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1036 regfile.registers\[22\]\[30\] VGND VGND VPWR VPWR net1116 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1025 regfile.registers\[25\]\[2\] VGND VGND VPWR VPWR net1105 sky130_fd_sc_hd__dlygate4sd3_1
X_6967_ net246 _3145_ _3398_ VGND VGND VPWR VPWR _3404_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5918_ _2175_ _2659_ _2660_ VGND VGND VPWR VPWR _2662_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_62_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8706_ clknet_leaf_87_CLK _0890_ VGND VGND VPWR VPWR regfile.registers\[15\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_6898_ _3367_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5849_ _1528_ _2596_ VGND VGND VPWR VPWR _2597_ sky130_fd_sc_hd__xor2_2
X_8637_ clknet_leaf_12_CLK _0821_ VGND VGND VPWR VPWR regfile.registers\[17\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8568_ clknet_leaf_17_CLK _0752_ VGND VGND VPWR VPWR regfile.registers\[10\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_7519_ _3713_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8499_ _4232_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_102_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold881 regfile.registers\[26\]\[13\] VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__dlygate4sd3_1
Xhold870 regfile.registers\[30\]\[2\] VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlygate4sd3_1
Xhold892 regfile.registers\[20\]\[30\] VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_17_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7870_ net230 _3527_ _3891_ VGND VGND VPWR VPWR _3899_ sky130_fd_sc_hd__mux2_1
X_6821_ _3326_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_35_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9540_ clknet_leaf_90_CLK _0700_ VGND VGND VPWR VPWR regfile.registers\[11\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_6752_ net432 _3134_ _3289_ VGND VGND VPWR VPWR _3290_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6683_ _3230_ VGND VGND VPWR VPWR _3253_ sky130_fd_sc_hd__clkbuf_8
X_5703_ _2368_ _2367_ VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9471_ clknet_leaf_79_CLK _0631_ VGND VGND VPWR VPWR regfile.registers\[16\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5634_ _2388_ VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__inv_2
X_8422_ net382 _3533_ _4191_ VGND VGND VPWR VPWR _4192_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8353_ _4132_ VGND VGND VPWR VPWR _4155_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_72_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7304_ _3037_ net875 _3591_ VGND VGND VPWR VPWR _3599_ sky130_fd_sc_hd__mux2_1
Xhold100 regfile.registers\[6\]\[0\] VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
X_5565_ _2319_ _2320_ _2044_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__mux2_1
Xhold111 regfile.registers\[19\]\[25\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 regfile.registers\[18\]\[24\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
X_4516_ _1214_ _1271_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold133 regfile.registers\[6\]\[23\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
X_5496_ _2251_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__clkbuf_4
Xhold122 regfile.registers\[11\]\[31\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
X_8284_ _4118_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_44_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold155 regfile.registers\[12\]\[21\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold166 regfile.registers\[5\]\[25\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold177 regfile.registers\[17\]\[20\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
X_4447_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__buf_4
X_7235_ _3561_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_129_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold199 regfile.registers\[24\]\[10\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7166_ net20 VGND VGND VPWR VPWR _3519_ sky130_fd_sc_hd__buf_2
Xhold188 regfile.registers\[9\]\[4\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6117_ _2549_ _2823_ _2731_ _2705_ _2850_ VGND VGND VPWR VPWR _2851_ sky130_fd_sc_hd__a221o_1
X_4378_ _1132_ _1133_ _1035_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__mux2_1
X_7097_ _3473_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6048_ _1820_ _2768_ VGND VGND VPWR VPWR _2785_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_53_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7999_ _3967_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_62_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5350_ regfile.registers\[20\]\[15\] regfile.registers\[21\]\[15\] regfile.registers\[22\]\[15\]
+ regfile.registers\[23\]\[15\] _1734_ _1680_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__mux4_1
XFILLER_0_50_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5281_ _1999_ _2036_ _1877_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__mux2_2
X_4301_ net8 VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__buf_4
XFILLER_0_49_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7020_ net1055 _3130_ _3423_ VGND VGND VPWR VPWR _3432_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8971_ clknet_leaf_98_CLK _0131_ VGND VGND VPWR VPWR regfile.registers\[7\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_7922_ _3926_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_81_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7853_ net188 _3510_ _3880_ VGND VGND VPWR VPWR _3890_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4996_ _1750_ _1751_ _1739_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__mux2_1
X_7784_ _3853_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__clkbuf_1
X_6804_ _3317_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9523_ clknet_leaf_34_CLK _0683_ VGND VGND VPWR VPWR regfile.registers\[12\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_6735_ net903 _3118_ _3278_ VGND VGND VPWR VPWR _3281_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9454_ clknet_leaf_20_CLK _0614_ VGND VGND VPWR VPWR regfile.registers\[13\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6666_ _3244_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5617_ _1060_ _2101_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__and2_1
X_9385_ clknet_leaf_101_CLK _0545_ VGND VGND VPWR VPWR regfile.registers\[24\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_8405_ net728 _3517_ _4180_ VGND VGND VPWR VPWR _4183_ sky130_fd_sc_hd__mux2_1
X_6597_ _3207_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__clkbuf_1
X_8336_ _4146_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__clkbuf_1
X_5548_ _1696_ _2303_ _1670_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_57_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8267_ _3116_ net485 _4108_ VGND VGND VPWR VPWR _4110_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7218_ _3447_ _3338_ VGND VGND VPWR VPWR _3552_ sky130_fd_sc_hd__nor2_2
X_5479_ regfile.registers\[16\]\[9\] regfile.registers\[17\]\[9\] regfile.registers\[18\]\[9\]
+ regfile.registers\[19\]\[9\] _1675_ _1692_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8198_ _4073_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__clkbuf_1
X_7149_ _3507_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_122_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_70_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4850_ regfile.registers\[28\]\[19\] regfile.registers\[29\]\[19\] regfile.registers\[30\]\[19\]
+ regfile.registers\[31\]\[19\] net1150 _1222_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__mux4_1
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6520_ _3041_ net646 _3155_ VGND VGND VPWR VPWR _3165_ sky130_fd_sc_hd__mux2_1
X_4781_ _1040_ _1536_ _1037_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6451_ net561 _3122_ _3114_ VGND VGND VPWR VPWR _3123_ sky130_fd_sc_hd__mux2_1
Xclkload20 clknet_leaf_110_CLK VGND VGND VPWR VPWR clkload20/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload42 clknet_leaf_29_CLK VGND VGND VPWR VPWR clkload42/Y sky130_fd_sc_hd__clkinvlp_2
X_6382_ net33 VGND VGND VPWR VPWR _3075_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_113_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload53 clknet_leaf_38_CLK VGND VGND VPWR VPWR clkload53/X sky130_fd_sc_hd__clkbuf_4
X_9170_ clknet_leaf_45_CLK _0330_ VGND VGND VPWR VPWR regfile.registers\[2\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload31 clknet_leaf_105_CLK VGND VGND VPWR VPWR clkload31/Y sky130_fd_sc_hd__clkinvlp_4
X_5402_ _2156_ _2157_ net3 VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload64 clknet_leaf_83_CLK VGND VGND VPWR VPWR clkload64/Y sky130_fd_sc_hd__bufinv_16
XFILLER_0_23_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload86 clknet_leaf_77_CLK VGND VGND VPWR VPWR clkload86/Y sky130_fd_sc_hd__inv_6
Xclkload75 clknet_leaf_100_CLK VGND VGND VPWR VPWR clkload75/Y sky130_fd_sc_hd__clkinv_4
X_5333_ regfile.registers\[4\]\[1\] regfile.registers\[5\]\[1\] regfile.registers\[6\]\[1\]
+ regfile.registers\[7\]\[1\] _1641_ _1642_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__mux4_1
X_8121_ _4032_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__clkbuf_1
Xclkload97 clknet_leaf_55_CLK VGND VGND VPWR VPWR clkload97/Y sky130_fd_sc_hd__bufinv_16
X_5264_ _2018_ _2019_ _1901_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8052_ net861 _3504_ _3989_ VGND VGND VPWR VPWR _3996_ sky130_fd_sc_hd__mux2_1
X_5195_ _1889_ _1950_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7003_ _3411_ VGND VGND VPWR VPWR _3423_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_39_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8954_ clknet_leaf_16_CLK _0114_ VGND VGND VPWR VPWR regfile.registers\[3\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_8885_ clknet_leaf_32_CLK _0045_ VGND VGND VPWR VPWR regfile.registers\[4\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7905_ _3095_ net712 _3916_ VGND VGND VPWR VPWR _3918_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7836_ _3881_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4979_ _1721_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__clkbuf_8
X_7767_ net813 _3490_ _3844_ VGND VGND VPWR VPWR _3845_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7698_ _3807_ VGND VGND VPWR VPWR _3808_ sky130_fd_sc_hd__clkbuf_8
X_9506_ clknet_leaf_87_CLK _0666_ VGND VGND VPWR VPWR regfile.registers\[12\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_6718_ net703 _3101_ _3267_ VGND VGND VPWR VPWR _3272_ sky130_fd_sc_hd__mux2_1
Xclkload3 clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clkload3/X sky130_fd_sc_hd__clkbuf_8
X_9437_ clknet_leaf_44_CLK _0597_ VGND VGND VPWR VPWR regfile.registers\[1\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_6649_ _3235_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_119_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_119_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9368_ clknet_leaf_19_CLK _0528_ VGND VGND VPWR VPWR regfile.registers\[20\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9299_ clknet_leaf_28_CLK _0459_ VGND VGND VPWR VPWR regfile.registers\[25\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_8319_ _4137_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_83_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_109_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_109_CLK
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_94_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5951_ _2522_ _2605_ _2591_ _2531_ VGND VGND VPWR VPWR _2694_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4902_ _1656_ _1657_ _1645_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__mux2_1
X_8670_ clknet_leaf_71_CLK _0854_ VGND VGND VPWR VPWR regfile.registers\[0\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_5882_ _2441_ _2588_ _2590_ _2444_ VGND VGND VPWR VPWR _2628_ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_103_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7621_ _3081_ net643 _3758_ VGND VGND VPWR VPWR _3767_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4833_ regfile.registers\[28\]\[17\] regfile.registers\[29\]\[17\] regfile.registers\[30\]\[17\]
+ regfile.registers\[31\]\[17\] _1191_ _1174_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_44_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7552_ _3730_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4764_ regfile.registers\[12\]\[8\] regfile.registers\[13\]\[8\] regfile.registers\[14\]\[8\]
+ regfile.registers\[15\]\[8\] _1149_ _1028_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7483_ _3079_ net541 _3686_ VGND VGND VPWR VPWR _3694_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6503_ _3156_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_126_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9222_ clknet_leaf_56_CLK _0382_ VGND VGND VPWR VPWR regfile.registers\[9\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6434_ net47 VGND VGND VPWR VPWR _3111_ sky130_fd_sc_hd__buf_2
X_4695_ _1449_ _1450_ _1036_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6365_ _3063_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9153_ clknet_leaf_65_CLK _0313_ VGND VGND VPWR VPWR regfile.registers\[2\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_9084_ clknet_leaf_41_CLK _0244_ VGND VGND VPWR VPWR regfile.registers\[26\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6296_ net423 _3015_ _3007_ VGND VGND VPWR VPWR _3016_ sky130_fd_sc_hd__mux2_1
X_8104_ net1097 _3488_ _3988_ VGND VGND VPWR VPWR _4023_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5316_ regfile.registers\[8\]\[2\] regfile.registers\[9\]\[2\] regfile.registers\[10\]\[2\]
+ regfile.registers\[11\]\[2\] _1701_ _1677_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__mux4_1
X_5247_ regfile.registers\[28\]\[25\] regfile.registers\[29\]\[25\] regfile.registers\[30\]\[25\]
+ regfile.registers\[31\]\[25\] _1822_ _1823_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__mux4_1
X_8035_ _3017_ net970 _3951_ VGND VGND VPWR VPWR _3986_ sky130_fd_sc_hd__mux2_1
Xhold37 regfile.registers\[1\]\[27\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
X_5178_ regfile.registers\[4\]\[29\] regfile.registers\[5\]\[29\] regfile.registers\[6\]\[29\]
+ regfile.registers\[7\]\[29\] _1767_ _1768_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__mux4_1
Xhold59 regfile.registers\[18\]\[20\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 regfile.registers\[2\]\[20\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
X_8937_ clknet_leaf_97_CLK _0097_ VGND VGND VPWR VPWR regfile.registers\[3\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8868_ clknet_leaf_64_CLK _0028_ VGND VGND VPWR VPWR regfile.registers\[4\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_7819_ net166 _3544_ _3866_ VGND VGND VPWR VPWR _3872_ sky130_fd_sc_hd__mux2_1
X_8799_ clknet_leaf_65_CLK _0983_ VGND VGND VPWR VPWR regfile.registers\[6\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_750 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold507 regfile.registers\[0\]\[23\] VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__dlygate4sd3_1
X_4480_ _1230_ _1232_ _1235_ _1205_ _1215_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__o221a_4
Xhold518 regfile.registers\[26\]\[20\] VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold529 regfile.registers\[11\]\[1\] VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_122_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6150_ _2840_ _2843_ _2854_ _2880_ _2881_ VGND VGND VPWR VPWR _2882_ sky130_fd_sc_hd__o311a_1
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5101_ _1717_ _1856_ _1729_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__a21oi_1
X_6081_ _2814_ _2815_ _2748_ _2816_ VGND VGND VPWR VPWR _2817_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5032_ _1786_ _1787_ _1739_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6983_ net752 _3089_ _3412_ VGND VGND VPWR VPWR _3413_ sky130_fd_sc_hd__mux2_1
X_5934_ _2502_ _2677_ _2104_ VGND VGND VPWR VPWR _2678_ sky130_fd_sc_hd__mux2_1
X_8722_ clknet_leaf_45_CLK _0906_ VGND VGND VPWR VPWR regfile.registers\[15\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_5865_ _2426_ _2608_ _2611_ VGND VGND VPWR VPWR _2612_ sky130_fd_sc_hd__o21ai_1
X_8653_ clknet_leaf_95_CLK _0837_ VGND VGND VPWR VPWR regfile.registers\[22\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7604_ _3735_ VGND VGND VPWR VPWR _3758_ sky130_fd_sc_hd__clkbuf_8
X_4816_ _1025_ _1563_ _1567_ _1571_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_113_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5796_ _2363_ _1758_ _2331_ _2419_ VGND VGND VPWR VPWR _2546_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_75_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8584_ clknet_leaf_101_CLK _0768_ VGND VGND VPWR VPWR regfile.registers\[23\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7535_ _3721_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4747_ regfile.registers\[8\]\[15\] regfile.registers\[9\]\[15\] regfile.registers\[10\]\[15\]
+ regfile.registers\[11\]\[15\] _1201_ _1203_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__mux4_1
X_4678_ regfile.registers\[28\]\[22\] regfile.registers\[29\]\[22\] regfile.registers\[30\]\[22\]
+ regfile.registers\[31\]\[22\] _1182_ _1184_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__mux4_1
X_7466_ _3062_ net1114 _3675_ VGND VGND VPWR VPWR _3685_ sky130_fd_sc_hd__mux2_1
X_9205_ clknet_leaf_29_CLK _0365_ VGND VGND VPWR VPWR regfile.registers\[30\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_116_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7397_ _3062_ net722 _3638_ VGND VGND VPWR VPWR _3648_ sky130_fd_sc_hd__mux2_1
X_6417_ net227 _3099_ _3093_ VGND VGND VPWR VPWR _3100_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput49 net49 VGND VGND VPWR VPWR ALUResult[0] sky130_fd_sc_hd__buf_6
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6348_ net21 VGND VGND VPWR VPWR _3052_ sky130_fd_sc_hd__clkbuf_2
X_9136_ clknet_leaf_8_CLK _0296_ VGND VGND VPWR VPWR regfile.registers\[28\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6279_ net13 net11 net12 VGND VGND VPWR VPWR _3003_ sky130_fd_sc_hd__or3b_4
X_9067_ clknet_leaf_104_CLK _0227_ VGND VGND VPWR VPWR regfile.registers\[26\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_8018_ _3977_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_127_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_40_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_40_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_120_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5650_ _2404_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__inv_2
XFILLER_0_45_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4601_ regfile.registers\[24\]\[25\] regfile.registers\[25\]\[25\] regfile.registers\[26\]\[25\]
+ regfile.registers\[27\]\[25\] _1351_ _1352_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__mux4_1
XFILLER_0_72_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5581_ _1111_ _1126_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__nand2_2
XFILLER_0_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4532_ regfile.registers\[4\]\[26\] regfile.registers\[5\]\[26\] regfile.registers\[6\]\[26\]
+ regfile.registers\[7\]\[26\] _1191_ _1174_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__mux4_1
X_7320_ _3607_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold326 regfile.registers\[21\]\[7\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
X_7251_ net183 _3523_ _3564_ VGND VGND VPWR VPWR _3570_ sky130_fd_sc_hd__mux2_1
X_4463_ _1089_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__buf_12
Xhold315 regfile.registers\[6\]\[10\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
Xhold304 regfile.registers\[13\]\[6\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6202_ _2595_ _2929_ VGND VGND VPWR VPWR _2930_ sky130_fd_sc_hd__and2_1
Xhold359 regfile.registers\[16\]\[30\] VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__dlygate4sd3_1
Xhold348 regfile.registers\[21\]\[13\] VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__dlygate4sd3_1
Xhold337 regfile.registers\[10\]\[1\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_31_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_31_CLK sky130_fd_sc_hd__clkbuf_8
X_7182_ net360 _3529_ _3513_ VGND VGND VPWR VPWR _3530_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4394_ regfile.registers\[20\]\[0\] regfile.registers\[21\]\[0\] regfile.registers\[22\]\[0\]
+ regfile.registers\[23\]\[0\] _1149_ _1061_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_699 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6133_ _2038_ _2864_ VGND VGND VPWR VPWR _2865_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6064_ _1840_ _1801_ VGND VGND VPWR VPWR _2800_ sky130_fd_sc_hd__and2b_1
Xhold1015 regfile.registers\[15\]\[24\] VGND VGND VPWR VPWR net1095 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1004 regfile.registers\[31\]\[1\] VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__dlygate4sd3_1
X_5015_ _1769_ _1770_ _1713_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__mux2_1
Xhold1037 regfile.registers\[16\]\[31\] VGND VGND VPWR VPWR net1117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1048 regfile.registers\[28\]\[11\] VGND VGND VPWR VPWR net1128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1026 regfile.registers\[22\]\[10\] VGND VGND VPWR VPWR net1106 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6966_ _3403_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_98_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_98_CLK sky130_fd_sc_hd__clkbuf_8
X_5917_ _2659_ _2660_ _2175_ VGND VGND VPWR VPWR _2661_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_62_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8705_ clknet_leaf_82_CLK _0889_ VGND VGND VPWR VPWR regfile.registers\[15\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_24_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6897_ net338 _3143_ _3362_ VGND VGND VPWR VPWR _3367_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8636_ clknet_leaf_42_CLK _0820_ VGND VGND VPWR VPWR regfile.registers\[17\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_5848_ net1140 _2593_ _2594_ _2595_ VGND VGND VPWR VPWR _2596_ sky130_fd_sc_hd__o31a_1
X_8567_ _4267_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__clkbuf_1
X_5779_ _1111_ VGND VGND VPWR VPWR _2530_ sky130_fd_sc_hd__buf_2
XFILLER_0_17_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7518_ _3046_ net1123 _3711_ VGND VGND VPWR VPWR _3713_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8498_ net154 net32 _4227_ VGND VGND VPWR VPWR _4232_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7449_ _3676_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold882 regfile.registers\[30\]\[22\] VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_22_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_22_CLK sky130_fd_sc_hd__clkbuf_8
Xhold871 regfile.registers\[13\]\[4\] VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlygate4sd3_1
Xhold860 regfile.registers\[14\]\[2\] VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__dlygate4sd3_1
Xhold893 regfile.registers\[23\]\[23\] VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9119_ clknet_leaf_79_CLK _0279_ VGND VGND VPWR VPWR regfile.registers\[28\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_4_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_89_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_89_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_79_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_13_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_13_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6820_ _3064_ net659 _3325_ VGND VGND VPWR VPWR _3326_ sky130_fd_sc_hd__mux2_1
X_6751_ _3266_ VGND VGND VPWR VPWR _3289_ sky130_fd_sc_hd__clkbuf_8
X_5702_ _2339_ VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__inv_2
X_6682_ _3252_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__clkbuf_1
X_9470_ clknet_leaf_70_CLK _0630_ VGND VGND VPWR VPWR regfile.registers\[16\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5633_ _2385_ _2387_ _1145_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__mux2_1
X_8421_ _4168_ VGND VGND VPWR VPWR _4191_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_73_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8352_ _4154_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5564_ regfile.registers\[0\]\[5\] regfile.registers\[1\]\[5\] regfile.registers\[2\]\[5\]
+ regfile.registers\[3\]\[5\] _1733_ _1679_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__mux4_1
X_4515_ _1269_ _1270_ _1190_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__mux2_1
Xhold101 regfile.registers\[17\]\[0\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
X_7303_ _3598_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold112 regfile.registers\[7\]\[24\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5495_ net84 VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__buf_2
X_8283_ _3132_ net393 _4108_ VGND VGND VPWR VPWR _4118_ sky130_fd_sc_hd__mux2_1
Xhold134 regfile.registers\[5\]\[15\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 regfile.registers\[1\]\[10\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 regfile.registers\[17\]\[24\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
Xhold167 regfile.registers\[6\]\[27\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
X_7234_ net787 _3506_ _3553_ VGND VGND VPWR VPWR _3561_ sky130_fd_sc_hd__mux2_1
Xhold156 regfile.registers\[17\]\[11\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
X_4446_ _1029_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__clkbuf_4
Xhold189 regfile.registers\[10\]\[16\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
Xhold178 regfile.registers\[19\]\[9\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
X_4377_ regfile.registers\[24\]\[1\] regfile.registers\[25\]\[1\] regfile.registers\[26\]\[1\]
+ regfile.registers\[27\]\[1\] net86 _1043_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__mux4_1
X_7165_ _3518_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_129_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6116_ _2495_ _2849_ _2503_ VGND VGND VPWR VPWR _2850_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7096_ net778 _3137_ _3471_ VGND VGND VPWR VPWR _3473_ sky130_fd_sc_hd__mux2_1
X_6047_ _1838_ _2783_ VGND VGND VPWR VPWR _2784_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7998_ _3120_ net428 _3963_ VGND VGND VPWR VPWR _3967_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6949_ _3394_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8619_ clknet_leaf_105_CLK _0803_ VGND VGND VPWR VPWR regfile.registers\[17\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold690 regfile.registers\[23\]\[18\] VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_115_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_2_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_2_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_15_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5280_ _2017_ _2035_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__or2_1
X_4300_ _1054_ _1055_ _1047_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8970_ clknet_leaf_0_CLK _0130_ VGND VGND VPWR VPWR regfile.registers\[7\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_7921_ _3111_ net1037 _3916_ VGND VGND VPWR VPWR _3926_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7852_ _3889_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4995_ regfile.registers\[0\]\[22\] regfile.registers\[1\]\[22\] regfile.registers\[2\]\[22\]
+ regfile.registers\[3\]\[22\] _1704_ _1707_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__mux4_1
XFILLER_0_77_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7783_ net823 _3508_ _3844_ VGND VGND VPWR VPWR _3853_ sky130_fd_sc_hd__mux2_1
X_6803_ _3048_ net642 _3314_ VGND VGND VPWR VPWR _3317_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9522_ clknet_leaf_47_CLK _0682_ VGND VGND VPWR VPWR regfile.registers\[12\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_6734_ _3280_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9453_ clknet_leaf_97_CLK _0613_ VGND VGND VPWR VPWR regfile.registers\[13\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6665_ _3046_ net732 _3242_ VGND VGND VPWR VPWR _3244_ sky130_fd_sc_hd__mux2_1
X_8404_ _4182_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__clkbuf_1
X_5616_ _2366_ _2367_ _2370_ _2336_ VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__a211o_1
X_9384_ clknet_leaf_102_CLK _0544_ VGND VGND VPWR VPWR regfile.registers\[24\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_6596_ net574 _3116_ _3205_ VGND VGND VPWR VPWR _3207_ sky130_fd_sc_hd__mux2_1
X_8335_ net965 _3515_ _4144_ VGND VGND VPWR VPWR _4146_ sky130_fd_sc_hd__mux2_1
X_5547_ _2301_ _2302_ _1738_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__mux2_1
X_5478_ regfile.registers\[20\]\[9\] regfile.registers\[21\]\[9\] regfile.registers\[22\]\[9\]
+ regfile.registers\[23\]\[9\] _1675_ _1692_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_57_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8266_ _4109_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__clkbuf_1
X_4429_ regfile.registers\[24\]\[29\] regfile.registers\[25\]\[29\] regfile.registers\[26\]\[29\]
+ regfile.registers\[27\]\[29\] _1182_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__mux4_2
X_7217_ _3551_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_57_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8197_ net203 _3512_ _4072_ VGND VGND VPWR VPWR _4073_ sky130_fd_sc_hd__mux2_1
X_7148_ net966 _3506_ _3492_ VGND VGND VPWR VPWR _3507_ sky130_fd_sc_hd__mux2_1
X_7079_ net1009 _3120_ _3460_ VGND VGND VPWR VPWR _3464_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4780_ regfile.registers\[12\]\[9\] regfile.registers\[13\]\[9\] regfile.registers\[14\]\[9\]
+ regfile.registers\[15\]\[9\] _1104_ _1105_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_31_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_751 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6450_ net21 VGND VGND VPWR VPWR _3122_ sky130_fd_sc_hd__buf_2
Xclkload10 clknet_leaf_3_CLK VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinvlp_2
X_6381_ _3074_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__clkbuf_1
Xclkload43 clknet_leaf_30_CLK VGND VGND VPWR VPWR clkload43/Y sky130_fd_sc_hd__inv_8
Xclkload21 clknet_leaf_111_CLK VGND VGND VPWR VPWR clkload21/Y sky130_fd_sc_hd__clkinv_8
Xclkload32 clknet_leaf_106_CLK VGND VGND VPWR VPWR clkload32/Y sky130_fd_sc_hd__clkinv_4
X_5401_ regfile.registers\[12\]\[13\] regfile.registers\[13\]\[13\] regfile.registers\[14\]\[13\]
+ regfile.registers\[15\]\[13\] _1702_ _1678_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__mux4_1
Xclkload54 clknet_leaf_39_CLK VGND VGND VPWR VPWR clkload54/Y sky130_fd_sc_hd__clkinv_1
Xclkload87 clknet_leaf_78_CLK VGND VGND VPWR VPWR clkload87/Y sky130_fd_sc_hd__inv_6
X_5332_ _2084_ _2085_ _2086_ _2087_ net3 _1655_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__mux4_2
XFILLER_0_11_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload65 clknet_leaf_85_CLK VGND VGND VPWR VPWR clkload65/Y sky130_fd_sc_hd__bufinv_16
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload76 clknet_leaf_101_CLK VGND VGND VPWR VPWR clkload76/Y sky130_fd_sc_hd__clkinv_1
X_8120_ net691 _3504_ _4025_ VGND VGND VPWR VPWR _4032_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload98 clknet_leaf_56_CLK VGND VGND VPWR VPWR clkload98/Y sky130_fd_sc_hd__clkinvlp_4
X_5263_ regfile.registers\[16\]\[24\] regfile.registers\[17\]\[24\] regfile.registers\[18\]\[24\]
+ regfile.registers\[19\]\[24\] _1918_ _1919_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8051_ _3995_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__clkbuf_1
X_5194_ regfile.registers\[4\]\[28\] regfile.registers\[5\]\[28\] regfile.registers\[6\]\[28\]
+ regfile.registers\[7\]\[28\] _1896_ _1898_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__mux4_1
X_7002_ _3422_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_39_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8953_ clknet_leaf_48_CLK _0113_ VGND VGND VPWR VPWR regfile.registers\[3\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_8884_ clknet_leaf_16_CLK _0044_ VGND VGND VPWR VPWR regfile.registers\[4\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_7904_ _3917_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7835_ net534 _3490_ _3880_ VGND VGND VPWR VPWR _3881_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7766_ _3843_ VGND VGND VPWR VPWR _3844_ sky130_fd_sc_hd__clkbuf_8
X_9505_ clknet_leaf_81_CLK _0665_ VGND VGND VPWR VPWR regfile.registers\[12\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4978_ _1733_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__clkbuf_8
X_7697_ _3153_ _3589_ VGND VGND VPWR VPWR _3807_ sky130_fd_sc_hd__nand2_4
X_6717_ _3271_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__clkbuf_1
Xclkload4 clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_46_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9436_ clknet_leaf_45_CLK _0596_ VGND VGND VPWR VPWR regfile.registers\[1\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6648_ _3029_ net839 _3231_ VGND VGND VPWR VPWR _3235_ sky130_fd_sc_hd__mux2_1
X_9367_ clknet_leaf_35_CLK _0527_ VGND VGND VPWR VPWR regfile.registers\[20\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_119_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8318_ net1038 _3498_ _4133_ VGND VGND VPWR VPWR _4137_ sky130_fd_sc_hd__mux2_1
X_6579_ net808 _3099_ _3194_ VGND VGND VPWR VPWR _3198_ sky130_fd_sc_hd__mux2_1
X_9298_ clknet_leaf_45_CLK _0458_ VGND VGND VPWR VPWR regfile.registers\[25\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_8249_ _4100_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5950_ _2692_ _2679_ VGND VGND VPWR VPWR _2693_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4901_ regfile.registers\[0\]\[0\] regfile.registers\[1\]\[0\] regfile.registers\[2\]\[0\]
+ regfile.registers\[3\]\[0\] _1641_ _1642_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__mux4_1
X_7620_ _3766_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
X_5881_ _2335_ _2626_ VGND VGND VPWR VPWR _2627_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4832_ regfile.registers\[24\]\[17\] regfile.registers\[25\]\[17\] regfile.registers\[26\]\[17\]
+ regfile.registers\[27\]\[17\] _1291_ _1194_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_44_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7551_ _3079_ net525 _3722_ VGND VGND VPWR VPWR _3730_ sky130_fd_sc_hd__mux2_1
X_4763_ _1515_ _1518_ _1037_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__mux2_2
XFILLER_0_16_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7482_ _3693_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
X_4694_ regfile.registers\[16\]\[12\] regfile.registers\[17\]\[12\] regfile.registers\[18\]\[12\]
+ regfile.registers\[19\]\[12\] net95 _1221_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__mux4_1
X_6502_ _3019_ net724 _3155_ VGND VGND VPWR VPWR _3156_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6433_ _3110_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__clkbuf_1
X_9221_ clknet_leaf_63_CLK _0381_ VGND VGND VPWR VPWR regfile.registers\[9\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6364_ _3062_ net739 _3044_ VGND VGND VPWR VPWR _3063_ sky130_fd_sc_hd__mux2_1
X_9152_ clknet_leaf_76_CLK _0312_ VGND VGND VPWR VPWR regfile.registers\[2\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9083_ clknet_leaf_26_CLK _0243_ VGND VGND VPWR VPWR regfile.registers\[26\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_8103_ _4022_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__clkbuf_1
X_6295_ net39 VGND VGND VPWR VPWR _3015_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_54_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5315_ _2067_ _2070_ net4 VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__mux2_1
X_5246_ _2000_ _2001_ _1726_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__mux2_1
X_8034_ _3985_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold38 regfile.registers\[3\]\[27\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5177_ _1929_ _1932_ _1700_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__mux2_1
Xhold49 regfile.registers\[4\]\[9\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8936_ clknet_leaf_96_CLK _0096_ VGND VGND VPWR VPWR regfile.registers\[3\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_119_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8867_ clknet_leaf_90_CLK _0027_ VGND VGND VPWR VPWR regfile.registers\[4\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7818_ _3871_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8798_ clknet_leaf_68_CLK _0982_ VGND VGND VPWR VPWR regfile.registers\[6\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_7749_ _3073_ net614 _3830_ VGND VGND VPWR VPWR _3835_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9419_ clknet_leaf_97_CLK _0579_ VGND VGND VPWR VPWR regfile.registers\[1\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_128_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold508 regfile.registers\[12\]\[10\] VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold519 regfile.registers\[14\]\[29\] VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6080_ _2770_ _2809_ VGND VGND VPWR VPWR _2816_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5100_ _1854_ _1855_ _1726_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__mux2_1
X_5031_ regfile.registers\[24\]\[20\] regfile.registers\[25\]\[20\] regfile.registers\[26\]\[20\]
+ regfile.registers\[27\]\[20\] _1782_ _1680_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_49_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8721_ clknet_leaf_19_CLK _0905_ VGND VGND VPWR VPWR regfile.registers\[15\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_6982_ _3411_ VGND VGND VPWR VPWR _3412_ sky130_fd_sc_hd__buf_4
X_5933_ _2673_ _2676_ _2501_ VGND VGND VPWR VPWR _2677_ sky130_fd_sc_hd__mux2_1
X_5864_ _2252_ _2610_ VGND VGND VPWR VPWR _2611_ sky130_fd_sc_hd__nand2_1
X_8652_ clknet_leaf_110_CLK _0836_ VGND VGND VPWR VPWR regfile.registers\[22\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8583_ clknet_leaf_60_CLK _0767_ VGND VGND VPWR VPWR regfile.registers\[23\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_7603_ _3757_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4815_ _1088_ _1570_ net8 VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__a21oi_1
X_5795_ _2539_ _2540_ _2543_ VGND VGND VPWR VPWR _2545_ sky130_fd_sc_hd__or3_1
X_7534_ _3062_ net1033 _3711_ VGND VGND VPWR VPWR _3721_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4746_ _1498_ _1501_ _1187_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4677_ _1431_ _1432_ _1178_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__mux2_1
X_7465_ _3684_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9204_ clknet_leaf_22_CLK _0364_ VGND VGND VPWR VPWR regfile.registers\[30\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6416_ net41 VGND VGND VPWR VPWR _3099_ sky130_fd_sc_hd__buf_2
X_7396_ _3647_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
X_6347_ _3051_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__clkbuf_1
X_9135_ clknet_leaf_110_CLK _0295_ VGND VGND VPWR VPWR regfile.registers\[28\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_6278_ net34 VGND VGND VPWR VPWR _3002_ sky130_fd_sc_hd__buf_2
X_9066_ clknet_leaf_107_CLK _0226_ VGND VGND VPWR VPWR regfile.registers\[26\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_8017_ _3139_ net336 _3974_ VGND VGND VPWR VPWR _3977_ sky130_fd_sc_hd__mux2_1
X_5229_ regfile.registers\[24\]\[26\] regfile.registers\[25\]\[26\] regfile.registers\[26\]\[26\]
+ regfile.registers\[27\]\[26\] _1881_ _1883_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__mux4_1
XFILLER_0_98_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8919_ clknet_leaf_36_CLK _0079_ VGND VGND VPWR VPWR regfile.registers\[19\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4600_ regfile.registers\[28\]\[25\] regfile.registers\[29\]\[25\] regfile.registers\[30\]\[25\]
+ regfile.registers\[31\]\[25\] _1351_ _1352_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_100_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5580_ _1060_ _1085_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__nand2_2
XFILLER_0_72_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4531_ _1048_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__buf_4
X_4462_ regfile.registers\[20\]\[28\] regfile.registers\[21\]\[28\] regfile.registers\[22\]\[28\]
+ regfile.registers\[23\]\[28\] _1182_ _1184_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__mux4_1
Xhold305 regfile.registers\[25\]\[20\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
X_7250_ _3569_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
Xhold316 regfile.registers\[5\]\[17\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6201_ _1316_ _1385_ _2872_ VGND VGND VPWR VPWR _2929_ sky130_fd_sc_hd__or3_1
Xhold349 regfile.registers\[1\]\[30\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd3_1
Xhold327 regfile.registers\[29\]\[9\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold338 regfile.registers\[12\]\[5\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4393_ A2[0] VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__buf_6
X_7181_ net25 VGND VGND VPWR VPWR _3529_ sky130_fd_sc_hd__buf_2
X_6132_ _2104_ _2373_ VGND VGND VPWR VPWR _2864_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_111_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6063_ _2583_ _2733_ _2426_ VGND VGND VPWR VPWR _2799_ sky130_fd_sc_hd__mux2_1
Xhold1005 regfile.registers\[27\]\[5\] VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__dlygate4sd3_1
X_5014_ regfile.registers\[12\]\[21\] regfile.registers\[13\]\[21\] regfile.registers\[14\]\[21\]
+ regfile.registers\[15\]\[21\] _1767_ _1768_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__mux4_1
XFILLER_0_84_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1016 regfile.registers\[16\]\[1\] VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1038 regfile.registers\[23\]\[5\] VGND VGND VPWR VPWR net1118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1027 regfile.registers\[28\]\[5\] VGND VGND VPWR VPWR net1107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1049 regfile.registers\[14\]\[4\] VGND VGND VPWR VPWR net1129 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_108_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6965_ net115 _3143_ _3398_ VGND VGND VPWR VPWR _3403_ sky130_fd_sc_hd__mux2_1
X_5916_ _2536_ _2658_ net1149 VGND VGND VPWR VPWR _2660_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_62_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8704_ clknet_leaf_81_CLK _0888_ VGND VGND VPWR VPWR regfile.registers\[15\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_24_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8635_ clknet_leaf_27_CLK _0819_ VGND VGND VPWR VPWR regfile.registers\[17\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_6896_ _3366_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5847_ net14 _2503_ VGND VGND VPWR VPWR _2595_ sky130_fd_sc_hd__nand2_2
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8566_ net212 net33 _3006_ VGND VGND VPWR VPWR _4267_ sky130_fd_sc_hd__mux2_1
X_5778_ _1666_ _2523_ _2528_ _2495_ VGND VGND VPWR VPWR _2529_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_17_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8497_ _4231_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__clkbuf_1
X_7517_ _3712_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
X_4729_ _1481_ _1482_ _1483_ _1484_ _1189_ _1078_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__mux4_2
XFILLER_0_102_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7448_ _3043_ net1070 _3675_ VGND VGND VPWR VPWR _3676_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold861 regfile.registers\[26\]\[23\] VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlygate4sd3_1
Xhold850 regfile.registers\[27\]\[30\] VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__dlygate4sd3_1
Xhold872 regfile.registers\[21\]\[8\] VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7379_ _3043_ net971 _3638_ VGND VGND VPWR VPWR _3639_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_73_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold883 regfile.registers\[0\]\[18\] VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dlygate4sd3_1
Xhold894 regfile.registers\[0\]\[5\] VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__dlygate4sd3_1
X_9118_ clknet_leaf_72_CLK _0278_ VGND VGND VPWR VPWR regfile.registers\[28\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_9049_ clknet_leaf_35_CLK _0209_ VGND VGND VPWR VPWR regfile.registers\[31\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_4_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6750_ _3288_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5701_ _2422_ _2436_ _2446_ _2454_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__o31a_1
XFILLER_0_57_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6681_ _3062_ net943 _3242_ VGND VGND VPWR VPWR _3252_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5632_ _1168_ _1997_ _2386_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__o21ba_1
X_8420_ _4190_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8351_ net583 _3531_ _4144_ VGND VGND VPWR VPWR _4154_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5563_ regfile.registers\[4\]\[5\] regfile.registers\[5\]\[5\] regfile.registers\[6\]\[5\]
+ regfile.registers\[7\]\[5\] _1733_ _1679_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__mux4_1
X_4514_ regfile.registers\[12\]\[21\] regfile.registers\[13\]\[21\] regfile.registers\[14\]\[21\]
+ regfile.registers\[15\]\[21\] _1267_ _1268_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__mux4_1
XFILLER_0_53_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7302_ _3035_ net499 _3591_ VGND VGND VPWR VPWR _3598_ sky130_fd_sc_hd__mux2_1
Xhold113 regfile.registers\[19\]\[23\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
X_5494_ _2213_ _2249_ _2178_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold102 regfile.registers\[0\]\[15\] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold135 regfile.registers\[29\]\[14\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 regfile.registers\[11\]\[4\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
X_8282_ _4117_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__clkbuf_1
Xhold146 regfile.registers\[18\]\[21\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4445_ net1141 VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__buf_8
XFILLER_0_1_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold168 regfile.registers\[3\]\[1\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 regfile.registers\[25\]\[18\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
X_7233_ _3560_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
Xhold179 regfile.registers\[17\]\[7\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
X_4376_ regfile.registers\[28\]\[1\] regfile.registers\[29\]\[1\] regfile.registers\[30\]\[1\]
+ regfile.registers\[31\]\[1\] _1065_ _1066_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7164_ net446 _3517_ _3513_ VGND VGND VPWR VPWR _3518_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_129_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6115_ _2778_ _2848_ _1879_ VGND VGND VPWR VPWR _2849_ sky130_fd_sc_hd__mux2_1
X_7095_ _3472_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
X_6046_ _1618_ _2782_ VGND VGND VPWR VPWR _2783_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7997_ _3966_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6948_ net301 _3126_ _3387_ VGND VGND VPWR VPWR _3394_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6879_ _3357_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_715 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8618_ clknet_leaf_106_CLK _0802_ VGND VGND VPWR VPWR regfile.registers\[17\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_8549_ _4258_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold680 regfile.registers\[17\]\[16\] VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold691 regfile.registers\[2\]\[11\] VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7920_ _3925_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__clkbuf_1
X_7851_ net388 _3508_ _3880_ VGND VGND VPWR VPWR _3889_ sky130_fd_sc_hd__mux2_1
X_6802_ _3316_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__clkbuf_1
X_4994_ regfile.registers\[4\]\[22\] regfile.registers\[5\]\[22\] regfile.registers\[6\]\[22\]
+ regfile.registers\[7\]\[22\] _1704_ _1707_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__mux4_1
X_7782_ _3852_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9521_ clknet_leaf_19_CLK _0681_ VGND VGND VPWR VPWR regfile.registers\[12\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_6733_ net670 _3116_ _3278_ VGND VGND VPWR VPWR _3280_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9452_ clknet_leaf_110_CLK _0612_ VGND VGND VPWR VPWR regfile.registers\[13\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_6664_ _3243_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5615_ _2363_ _2368_ _2369_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__and3b_1
XFILLER_0_6_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8403_ net1053 _3515_ _4180_ VGND VGND VPWR VPWR _4182_ sky130_fd_sc_hd__mux2_1
XFILLER_0_116_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9383_ clknet_leaf_62_CLK _0543_ VGND VGND VPWR VPWR regfile.registers\[24\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6595_ _3206_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8334_ _4145_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__clkbuf_1
X_5546_ regfile.registers\[0\]\[4\] regfile.registers\[1\]\[4\] regfile.registers\[2\]\[4\]
+ regfile.registers\[3\]\[4\] _1733_ _1679_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__mux4_1
X_5477_ _2231_ _2232_ _1712_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8265_ _3113_ net709 _4108_ VGND VGND VPWR VPWR _4109_ sky130_fd_sc_hd__mux2_1
X_4428_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__buf_4
X_7216_ net244 _3488_ _3491_ VGND VGND VPWR VPWR _3551_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8196_ _4060_ VGND VGND VPWR VPWR _4072_ sky130_fd_sc_hd__buf_4
X_4359_ regfile.registers\[20\]\[2\] regfile.registers\[21\]\[2\] regfile.registers\[22\]\[2\]
+ regfile.registers\[23\]\[2\] _1042_ _1044_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__mux4_2
X_7147_ net45 VGND VGND VPWR VPWR _3506_ sky130_fd_sc_hd__buf_2
X_7078_ _3463_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
X_6029_ _1512_ _1602_ _2658_ _2536_ VGND VGND VPWR VPWR _2767_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_68_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6380_ _3073_ net711 _3065_ VGND VGND VPWR VPWR _3074_ sky130_fd_sc_hd__mux2_1
Xclkload44 clknet_leaf_31_CLK VGND VGND VPWR VPWR clkload44/Y sky130_fd_sc_hd__clkinv_4
Xclkload33 clknet_leaf_16_CLK VGND VGND VPWR VPWR clkload33/Y sky130_fd_sc_hd__bufinv_16
Xclkload11 clknet_leaf_4_CLK VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinvlp_2
X_5400_ regfile.registers\[8\]\[13\] regfile.registers\[9\]\[13\] regfile.registers\[10\]\[13\]
+ regfile.registers\[11\]\[13\] _1702_ _1678_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__mux4_1
Xclkbuf_3_5__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_5__leaf_CLK sky130_fd_sc_hd__clkbuf_16
Xclkload22 clknet_leaf_8_CLK VGND VGND VPWR VPWR clkload22/Y sky130_fd_sc_hd__clkinv_4
Xclkload55 clknet_leaf_40_CLK VGND VGND VPWR VPWR clkload55/Y sky130_fd_sc_hd__inv_6
X_5331_ regfile.registers\[20\]\[1\] regfile.registers\[21\]\[1\] regfile.registers\[22\]\[1\]
+ regfile.registers\[23\]\[1\] _1673_ _1690_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__mux4_1
Xclkload66 clknet_leaf_86_CLK VGND VGND VPWR VPWR clkload66/Y sky130_fd_sc_hd__clkinv_1
Xclkload77 clknet_leaf_102_CLK VGND VGND VPWR VPWR clkload77/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload99 clknet_leaf_57_CLK VGND VGND VPWR VPWR clkload99/Y sky130_fd_sc_hd__inv_6
X_8050_ net623 _3502_ _3989_ VGND VGND VPWR VPWR _3995_ sky130_fd_sc_hd__mux2_1
Xclkload88 clknet_leaf_79_CLK VGND VGND VPWR VPWR clkload88/Y sky130_fd_sc_hd__inv_6
X_5262_ regfile.registers\[20\]\[24\] regfile.registers\[21\]\[24\] regfile.registers\[22\]\[24\]
+ regfile.registers\[23\]\[24\] _1918_ _1919_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__mux4_1
X_7001_ net129 _3111_ _3412_ VGND VGND VPWR VPWR _3422_ sky130_fd_sc_hd__mux2_1
X_5193_ _1945_ _1946_ _1947_ _1948_ _1889_ _1773_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_39_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8952_ clknet_leaf_15_CLK _0112_ VGND VGND VPWR VPWR regfile.registers\[3\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_8883_ clknet_leaf_32_CLK _0043_ VGND VGND VPWR VPWR regfile.registers\[4\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_7903_ _3089_ net1121 _3916_ VGND VGND VPWR VPWR _3917_ sky130_fd_sc_hd__mux2_1
XFILLER_0_116_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7834_ _3879_ VGND VGND VPWR VPWR _3880_ sky130_fd_sc_hd__clkbuf_8
X_7765_ _3003_ _3091_ VGND VGND VPWR VPWR _3843_ sky130_fd_sc_hd__nor2_2
XFILLER_0_58_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9504_ clknet_leaf_78_CLK _0664_ VGND VGND VPWR VPWR regfile.registers\[12\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6716_ net559 _3099_ _3267_ VGND VGND VPWR VPWR _3271_ sky130_fd_sc_hd__mux2_1
X_4977_ _1702_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__clkbuf_8
Xclkload5 clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_16
X_7696_ _3806_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9435_ clknet_leaf_41_CLK _0595_ VGND VGND VPWR VPWR regfile.registers\[1\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_6647_ _3234_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__clkbuf_1
X_9366_ clknet_leaf_52_CLK _0526_ VGND VGND VPWR VPWR regfile.registers\[20\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6578_ _3197_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_119_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8317_ _4136_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__clkbuf_1
X_5529_ _1828_ _2284_ _1728_ VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__a21oi_1
X_9297_ clknet_leaf_5_CLK _0457_ VGND VGND VPWR VPWR regfile.registers\[25\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_8248_ _3097_ net1068 _4097_ VGND VGND VPWR VPWR _4100_ sky130_fd_sc_hd__mux2_1
X_8179_ _4063_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_83_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5880_ _2546_ _2570_ _2625_ _2105_ VGND VGND VPWR VPWR _2626_ sky130_fd_sc_hd__a22oi_2
X_4900_ regfile.registers\[4\]\[0\] regfile.registers\[5\]\[0\] regfile.registers\[6\]\[0\]
+ regfile.registers\[7\]\[0\] _1641_ _1642_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__mux4_1
X_4831_ _1215_ _1578_ _1582_ _1586_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_47_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7550_ _3729_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
X_4762_ _1516_ _1517_ _1035_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__mux2_1
X_7481_ _3077_ net1057 _3686_ VGND VGND VPWR VPWR _3693_ sky130_fd_sc_hd__mux2_1
X_6501_ _3154_ VGND VGND VPWR VPWR _3155_ sky130_fd_sc_hd__buf_6
X_4693_ regfile.registers\[20\]\[12\] regfile.registers\[21\]\[12\] regfile.registers\[22\]\[12\]
+ regfile.registers\[23\]\[12\] net95 _1221_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__mux4_1
XFILLER_0_113_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload100 clknet_leaf_59_CLK VGND VGND VPWR VPWR clkload100/Y sky130_fd_sc_hd__clkinvlp_2
X_6432_ net221 _3109_ _3093_ VGND VGND VPWR VPWR _3110_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9220_ clknet_leaf_90_CLK _0380_ VGND VGND VPWR VPWR regfile.registers\[9\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9151_ clknet_leaf_75_CLK _0311_ VGND VGND VPWR VPWR regfile.registers\[2\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_8102_ net972 _3486_ _3988_ VGND VGND VPWR VPWR _4022_ sky130_fd_sc_hd__mux2_1
X_6363_ net26 VGND VGND VPWR VPWR _3062_ sky130_fd_sc_hd__clkbuf_2
X_9082_ clknet_leaf_24_CLK _0242_ VGND VGND VPWR VPWR regfile.registers\[26\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_6294_ _3014_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5314_ _2068_ _2069_ _1645_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__mux2_1
X_5245_ regfile.registers\[16\]\[25\] regfile.registers\[17\]\[25\] regfile.registers\[18\]\[25\]
+ regfile.registers\[19\]\[25\] _1822_ _1823_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__mux4_1
X_8033_ _3015_ net1124 _3951_ VGND VGND VPWR VPWR _3985_ sky130_fd_sc_hd__mux2_1
X_5176_ _1930_ _1931_ _1726_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__mux2_1
Xhold39 regfile.registers\[17\]\[4\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_127_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8935_ clknet_leaf_59_CLK _0095_ VGND VGND VPWR VPWR regfile.registers\[3\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8866_ clknet_leaf_89_CLK _0026_ VGND VGND VPWR VPWR regfile.registers\[4\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_7817_ net161 _3542_ _3866_ VGND VGND VPWR VPWR _3871_ sky130_fd_sc_hd__mux2_1
X_8797_ clknet_leaf_14_CLK _0981_ VGND VGND VPWR VPWR regfile.registers\[14\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_7748_ _3834_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__clkbuf_1
X_7679_ net386 _3540_ _3794_ VGND VGND VPWR VPWR _3798_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9418_ clknet_leaf_8_CLK _0578_ VGND VGND VPWR VPWR regfile.registers\[1\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9349_ clknet_leaf_68_CLK _0509_ VGND VGND VPWR VPWR regfile.registers\[20\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_123_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold509 regfile.registers\[28\]\[7\] VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5030_ regfile.registers\[28\]\[20\] regfile.registers\[29\]\[20\] regfile.registers\[30\]\[20\]
+ regfile.registers\[31\]\[20\] _1782_ _1680_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_49_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6981_ _3192_ _3338_ VGND VGND VPWR VPWR _3411_ sky130_fd_sc_hd__nor2_2
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5932_ _2674_ _2675_ _1147_ VGND VGND VPWR VPWR _2676_ sky130_fd_sc_hd__mux2_1
X_8720_ clknet_leaf_6_CLK _0904_ VGND VGND VPWR VPWR regfile.registers\[15\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5863_ _2565_ _2609_ _1803_ VGND VGND VPWR VPWR _2610_ sky130_fd_sc_hd__mux2_1
X_8651_ clknet_leaf_104_CLK _0835_ VGND VGND VPWR VPWR regfile.registers\[22\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_5794_ _2539_ _2540_ _2543_ VGND VGND VPWR VPWR _2544_ sky130_fd_sc_hd__o21ai_1
X_8582_ clknet_leaf_55_CLK _0766_ VGND VGND VPWR VPWR regfile.registers\[23\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_7602_ _3062_ net1048 _3747_ VGND VGND VPWR VPWR _3757_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4814_ _1568_ _1569_ _1107_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4745_ _1499_ _1500_ _1259_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__mux2_1
X_7533_ _3720_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4676_ regfile.registers\[16\]\[22\] regfile.registers\[17\]\[22\] regfile.registers\[18\]\[22\]
+ regfile.registers\[19\]\[22\] _1182_ _1184_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7464_ _3060_ net1115 _3675_ VGND VGND VPWR VPWR _3684_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_116_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9203_ clknet_leaf_27_CLK _0363_ VGND VGND VPWR VPWR regfile.registers\[30\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_6415_ _3098_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7395_ _3060_ net688 _3638_ VGND VGND VPWR VPWR _3647_ sky130_fd_sc_hd__mux2_1
X_6346_ _3050_ net1103 _3044_ VGND VGND VPWR VPWR _3051_ sky130_fd_sc_hd__mux2_1
X_9134_ clknet_leaf_3_CLK _0294_ VGND VGND VPWR VPWR regfile.registers\[28\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9065_ clknet_leaf_101_CLK _0225_ VGND VGND VPWR VPWR regfile.registers\[26\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_8016_ _3976_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__clkbuf_1
X_6277_ _2621_ _2995_ _3001_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__o21bai_1
X_5228_ regfile.registers\[28\]\[26\] regfile.registers\[29\]\[26\] regfile.registers\[30\]\[26\]
+ regfile.registers\[31\]\[26\] _1881_ _1883_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__mux4_1
XFILLER_0_98_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5159_ _1913_ _1914_ _1889_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__mux2_1
X_8918_ clknet_leaf_52_CLK _0078_ VGND VGND VPWR VPWR regfile.registers\[19\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8849_ clknet_leaf_10_CLK _0009_ VGND VGND VPWR VPWR regfile.registers\[5\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4530_ _1282_ _1285_ _1071_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__mux2_2
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4461_ _1188_ _1171_ _1216_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__a21oi_4
Xhold306 regfile.registers\[2\]\[23\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
Xhold317 regfile.registers\[9\]\[10\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
Xhold328 regfile.registers\[22\]\[24\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
Xhold339 regfile.registers\[31\]\[27\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
X_6200_ _2621_ _2921_ _2928_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__o21bai_1
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7180_ _3528_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_4392_ _1147_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__clkbuf_4
X_6131_ _2586_ _2797_ VGND VGND VPWR VPWR _2863_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_111_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6062_ _2040_ _2796_ _2797_ _2421_ VGND VGND VPWR VPWR _2798_ sky130_fd_sc_hd__o31ai_1
Xhold1006 regfile.registers\[13\]\[7\] VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__dlygate4sd3_1
X_5013_ regfile.registers\[8\]\[21\] regfile.registers\[9\]\[21\] regfile.registers\[10\]\[21\]
+ regfile.registers\[11\]\[21\] _1767_ _1768_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__mux4_1
Xhold1028 regfile.registers\[14\]\[27\] VGND VGND VPWR VPWR net1108 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1017 regfile.registers\[20\]\[31\] VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1039 regfile.registers\[30\]\[9\] VGND VGND VPWR VPWR net1119 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6964_ _3402_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6895_ net213 _3141_ _3362_ VGND VGND VPWR VPWR _3366_ sky130_fd_sc_hd__mux2_1
X_5915_ net1149 _2536_ _2658_ VGND VGND VPWR VPWR _2659_ sky130_fd_sc_hd__or3_1
XFILLER_0_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8703_ clknet_leaf_81_CLK _0887_ VGND VGND VPWR VPWR regfile.registers\[15\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_24_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8634_ clknet_leaf_24_CLK _0818_ VGND VGND VPWR VPWR regfile.registers\[17\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5846_ _1060_ _1083_ VGND VGND VPWR VPWR _2594_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_62_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8565_ _4266_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__clkbuf_1
X_5777_ _2524_ _2527_ _2501_ VGND VGND VPWR VPWR _2528_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8496_ net435 net31 _4227_ VGND VGND VPWR VPWR _4231_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7516_ _3043_ net1013 _3711_ VGND VGND VPWR VPWR _3712_ sky130_fd_sc_hd__mux2_1
X_4728_ regfile.registers\[20\]\[14\] regfile.registers\[21\]\[14\] regfile.registers\[22\]\[14\]
+ regfile.registers\[23\]\[14\] _1324_ _1325_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__mux4_1
XFILLER_0_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7447_ _3663_ VGND VGND VPWR VPWR _3675_ sky130_fd_sc_hd__clkbuf_8
X_4659_ _1025_ _1406_ _1410_ _1414_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_102_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold873 regfile.registers\[29\]\[23\] VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlygate4sd3_1
Xhold862 regfile.registers\[24\]\[25\] VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlygate4sd3_1
Xhold851 regfile.registers\[21\]\[19\] VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__dlygate4sd3_1
X_7378_ _3626_ VGND VGND VPWR VPWR _3638_ sky130_fd_sc_hd__clkbuf_8
Xhold840 regfile.registers\[23\]\[4\] VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlygate4sd3_1
Xhold895 regfile.registers\[14\]\[22\] VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9117_ clknet_leaf_13_CLK _0277_ VGND VGND VPWR VPWR regfile.registers\[27\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_6329_ net46 VGND VGND VPWR VPWR _3039_ sky130_fd_sc_hd__buf_2
Xhold884 regfile.registers\[29\]\[5\] VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__dlygate4sd3_1
X_9048_ clknet_leaf_20_CLK _0208_ VGND VGND VPWR VPWR regfile.registers\[31\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_4_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5700_ _2452_ _2453_ _2421_ VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6680_ _3251_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_128_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5631_ _1167_ _2016_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5562_ _1716_ _2317_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__nor2_1
X_8350_ _4153_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__clkbuf_1
X_4513_ regfile.registers\[8\]\[21\] regfile.registers\[9\]\[21\] regfile.registers\[10\]\[21\]
+ regfile.registers\[11\]\[21\] _1267_ _1268_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7301_ _3597_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8281_ _3130_ net786 _4108_ VGND VGND VPWR VPWR _4117_ sky130_fd_sc_hd__mux2_1
XFILLER_0_123_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold114 regfile.registers\[20\]\[21\] VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5493_ _1669_ _2230_ _2248_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_80_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold103 regfile.registers\[7\]\[15\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 regfile.registers\[7\]\[12\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
X_7232_ net731 _3504_ _3553_ VGND VGND VPWR VPWR _3560_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_113_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold158 regfile.registers\[29\]\[8\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold147 regfile.registers\[17\]\[3\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4444_ _1027_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__buf_12
Xhold136 regfile.registers\[29\]\[16\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
Xhold169 regfile.registers\[1\]\[21\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
X_4375_ _1129_ _1130_ _1035_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7163_ net19 VGND VGND VPWR VPWR _3517_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_129_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6114_ _2800_ _2847_ _1877_ VGND VGND VPWR VPWR _2848_ sky130_fd_sc_hd__mux2_1
X_7094_ net239 _3134_ _3471_ VGND VGND VPWR VPWR _3472_ sky130_fd_sc_hd__mux2_1
X_6045_ _1512_ _1602_ _1634_ _2658_ _2536_ VGND VGND VPWR VPWR _2782_ sky130_fd_sc_hd__a41o_1
XPHY_EDGE_ROW_13_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7996_ _3118_ net494 _3963_ VGND VGND VPWR VPWR _3966_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6947_ _3393_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
X_6878_ net190 _3124_ _3351_ VGND VGND VPWR VPWR _3357_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5829_ _2418_ VGND VGND VPWR VPWR _2577_ sky130_fd_sc_hd__inv_2
X_8617_ clknet_leaf_99_CLK _0801_ VGND VGND VPWR VPWR regfile.registers\[17\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_106_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8548_ net269 net23 _4255_ VGND VGND VPWR VPWR _4258_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8479_ net178 net22 _4216_ VGND VGND VPWR VPWR _4222_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold681 regfile.registers\[13\]\[30\] VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlygate4sd3_1
Xhold670 regfile.registers\[0\]\[1\] VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_31_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold692 regfile.registers\[6\]\[14\] VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_86_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_750 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7850_ _3888_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__clkbuf_1
X_6801_ _3046_ net946 _3314_ VGND VGND VPWR VPWR _3316_ sky130_fd_sc_hd__mux2_1
XFILLER_0_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4993_ _1745_ _1746_ _1748_ _1697_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__o211a_1
X_7781_ net358 _3506_ _3844_ VGND VGND VPWR VPWR _3852_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6732_ _3279_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9520_ clknet_leaf_9_CLK _0680_ VGND VGND VPWR VPWR regfile.registers\[12\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_6663_ _3043_ net1006 _3242_ VGND VGND VPWR VPWR _3243_ sky130_fd_sc_hd__mux2_1
X_9451_ clknet_leaf_98_CLK _0611_ VGND VGND VPWR VPWR regfile.registers\[13\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5614_ _1799_ _2306_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_722 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8402_ _4181_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_121_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9382_ clknet_leaf_69_CLK _0542_ VGND VGND VPWR VPWR regfile.registers\[24\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6594_ net874 _3113_ _3205_ VGND VGND VPWR VPWR _3206_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8333_ net333 _3512_ _4144_ VGND VGND VPWR VPWR _4145_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5545_ regfile.registers\[4\]\[4\] regfile.registers\[5\]\[4\] regfile.registers\[6\]\[4\]
+ regfile.registers\[7\]\[4\] _1718_ _1679_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__mux4_1
XFILLER_0_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8264_ _4096_ VGND VGND VPWR VPWR _4108_ sky130_fd_sc_hd__clkbuf_8
X_5476_ regfile.registers\[28\]\[9\] regfile.registers\[29\]\[9\] regfile.registers\[30\]\[9\]
+ regfile.registers\[31\]\[9\] _1675_ _1692_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__mux4_1
X_7215_ _3550_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
X_8195_ _4071_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_57_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4427_ _1044_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7146_ _3505_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_70_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4358_ regfile.registers\[16\]\[2\] regfile.registers\[17\]\[2\] regfile.registers\[18\]\[2\]
+ regfile.registers\[19\]\[2\] _1052_ _1053_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__mux4_2
X_7077_ net288 _3118_ _3460_ VGND VGND VPWR VPWR _3463_ sky130_fd_sc_hd__mux2_1
X_4289_ regfile.registers\[4\]\[4\] regfile.registers\[5\]\[4\] regfile.registers\[6\]\[4\]
+ regfile.registers\[7\]\[4\] net96 _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__mux4_1
X_6028_ _2755_ _2760_ _2766_ _2621_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__o22a_1
XFILLER_0_68_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7979_ _3101_ net798 _3952_ VGND VGND VPWR VPWR _3957_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload34 clknet_leaf_17_CLK VGND VGND VPWR VPWR clkload34/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload12 clknet_leaf_6_CLK VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__bufinv_16
Xclkload23 clknet_leaf_9_CLK VGND VGND VPWR VPWR clkload23/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_113_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload45 clknet_leaf_32_CLK VGND VGND VPWR VPWR clkload45/Y sky130_fd_sc_hd__inv_6
Xclkload56 clknet_leaf_41_CLK VGND VGND VPWR VPWR clkload56/Y sky130_fd_sc_hd__bufinv_16
X_5330_ regfile.registers\[16\]\[1\] regfile.registers\[17\]\[1\] regfile.registers\[18\]\[1\]
+ regfile.registers\[19\]\[1\] _1673_ _1690_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload67 clknet_leaf_87_CLK VGND VGND VPWR VPWR clkload67/Y sky130_fd_sc_hd__inv_6
Xclkload78 clknet_leaf_65_CLK VGND VGND VPWR VPWR clkload78/Y sky130_fd_sc_hd__bufinv_16
X_5261_ _1668_ _2016_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__and2_1
Xclkload89 clknet_leaf_80_CLK VGND VGND VPWR VPWR clkload89/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_50_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7000_ _3421_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5192_ regfile.registers\[20\]\[28\] regfile.registers\[21\]\[28\] regfile.registers\[22\]\[28\]
+ regfile.registers\[23\]\[28\] _1882_ _1884_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__mux4_1
X_8951_ clknet_leaf_51_CLK _0111_ VGND VGND VPWR VPWR regfile.registers\[3\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7902_ _3915_ VGND VGND VPWR VPWR _3916_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_108_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8882_ clknet_leaf_59_CLK _0042_ VGND VGND VPWR VPWR regfile.registers\[4\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_121_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7833_ _3005_ _3090_ VGND VGND VPWR VPWR _3879_ sky130_fd_sc_hd__nor2_2
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7764_ _3842_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4976_ _1639_ _1731_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__or2_1
X_9503_ clknet_leaf_81_CLK _0663_ VGND VGND VPWR VPWR regfile.registers\[12\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6715_ _3270_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7695_ net465 _3488_ _3771_ VGND VGND VPWR VPWR _3806_ sky130_fd_sc_hd__mux2_1
X_9434_ clknet_leaf_16_CLK _0594_ VGND VGND VPWR VPWR regfile.registers\[1\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkload6 clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_8
XFILLER_0_6_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6646_ _3027_ net1065 _3231_ VGND VGND VPWR VPWR _3234_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_691 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9365_ clknet_leaf_29_CLK _0525_ VGND VGND VPWR VPWR regfile.registers\[20\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6577_ net369 _3097_ _3194_ VGND VGND VPWR VPWR _3197_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_119_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5528_ _2282_ _2283_ _1738_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8316_ net1133 _3496_ _4133_ VGND VGND VPWR VPWR _4136_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9296_ clknet_leaf_9_CLK _0456_ VGND VGND VPWR VPWR regfile.registers\[25\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_100_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5459_ regfile.registers\[16\]\[8\] regfile.registers\[17\]\[8\] regfile.registers\[18\]\[8\]
+ regfile.registers\[19\]\[8\] _2051_ _2053_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__mux4_1
X_8247_ _4099_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8178_ net163 _3494_ _4061_ VGND VGND VPWR VPWR _4063_ sky130_fd_sc_hd__mux2_1
X_7129_ net27 VGND VGND VPWR VPWR _3494_ sky130_fd_sc_hd__buf_2
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_70_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_70_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4830_ _1205_ _1585_ _1170_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_117_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4761_ regfile.registers\[24\]\[8\] regfile.registers\[25\]\[8\] regfile.registers\[26\]\[8\]
+ regfile.registers\[27\]\[8\] _1065_ _1066_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__mux4_1
X_7480_ _3692_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_4692_ _1416_ _1447_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__or2b_1
XFILLER_0_83_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6500_ _3153_ _3020_ VGND VGND VPWR VPWR _3154_ sky130_fd_sc_hd__nand2_4
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6431_ net46 VGND VGND VPWR VPWR _3109_ sky130_fd_sc_hd__buf_2
Xclkload101 clknet_leaf_61_CLK VGND VGND VPWR VPWR clkload101/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_3_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6362_ _3061_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__clkbuf_1
X_9150_ clknet_leaf_73_CLK _0310_ VGND VGND VPWR VPWR regfile.registers\[2\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_8101_ _4021_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_61_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_61_CLK sky130_fd_sc_hd__clkbuf_8
X_5313_ regfile.registers\[24\]\[2\] regfile.registers\[25\]\[2\] regfile.registers\[26\]\[2\]
+ regfile.registers\[27\]\[2\] _1701_ _1677_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__mux4_1
X_9081_ clknet_leaf_39_CLK _0241_ VGND VGND VPWR VPWR regfile.registers\[26\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_6293_ net299 _3013_ _3007_ VGND VGND VPWR VPWR _3014_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5244_ regfile.registers\[20\]\[25\] regfile.registers\[21\]\[25\] regfile.registers\[22\]\[25\]
+ regfile.registers\[23\]\[25\] _1822_ _1823_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__mux4_1
X_8032_ _3984_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5175_ regfile.registers\[24\]\[29\] regfile.registers\[25\]\[29\] regfile.registers\[26\]\[29\]
+ regfile.registers\[27\]\[29\] _1705_ _1708_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__mux4_1
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8934_ clknet_leaf_55_CLK _0094_ VGND VGND VPWR VPWR regfile.registers\[3\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_8865_ clknet_leaf_75_CLK _0025_ VGND VGND VPWR VPWR regfile.registers\[4\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_7816_ _3870_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_65_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8796_ clknet_leaf_14_CLK _0980_ VGND VGND VPWR VPWR regfile.registers\[14\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7747_ _3071_ net658 _3830_ VGND VGND VPWR VPWR _3834_ sky130_fd_sc_hd__mux2_1
X_4959_ _1700_ _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7678_ _3797_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6629_ net401 _3009_ _3216_ VGND VGND VPWR VPWR _3224_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_22_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9417_ clknet_leaf_97_CLK _0577_ VGND VGND VPWR VPWR regfile.registers\[1\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_52_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_52_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_104_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9348_ clknet_leaf_92_CLK _0508_ VGND VGND VPWR VPWR regfile.registers\[20\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_9279_ clknet_leaf_80_CLK _0439_ VGND VGND VPWR VPWR regfile.registers\[25\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_5_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_43_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_43_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_40_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6980_ _3410_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_105_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5931_ _1800_ _2194_ _2176_ VGND VGND VPWR VPWR _2675_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_69_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5862_ _2353_ _2358_ VGND VGND VPWR VPWR _2609_ sky130_fd_sc_hd__and2_1
X_8650_ clknet_leaf_107_CLK _0834_ VGND VGND VPWR VPWR regfile.registers\[22\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_5793_ _2511_ _2512_ _2518_ _2542_ VGND VGND VPWR VPWR _2543_ sky130_fd_sc_hd__a31oi_1
X_8581_ clknet_leaf_67_CLK _0765_ VGND VGND VPWR VPWR regfile.registers\[23\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4813_ regfile.registers\[0\]\[11\] regfile.registers\[1\]\[11\] regfile.registers\[2\]\[11\]
+ regfile.registers\[3\]\[11\] net99 _1090_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux4_1
X_7601_ _3756_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7532_ _3060_ net994 _3711_ VGND VGND VPWR VPWR _3720_ sky130_fd_sc_hd__mux2_1
X_4744_ regfile.registers\[24\]\[15\] regfile.registers\[25\]\[15\] regfile.registers\[26\]\[15\]
+ regfile.registers\[27\]\[15\] _1324_ _1325_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_60_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9202_ clknet_leaf_42_CLK _0362_ VGND VGND VPWR VPWR regfile.registers\[30\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_4675_ regfile.registers\[20\]\[22\] regfile.registers\[21\]\[22\] regfile.registers\[22\]\[22\]
+ regfile.registers\[23\]\[22\] _1182_ _1184_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__mux4_1
X_7463_ _3683_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_34_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_34_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_116_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6414_ net988 _3097_ _3093_ VGND VGND VPWR VPWR _3098_ sky130_fd_sc_hd__mux2_1
X_7394_ _3646_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9133_ clknet_leaf_95_CLK _0293_ VGND VGND VPWR VPWR regfile.registers\[28\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_6345_ net20 VGND VGND VPWR VPWR _3050_ sky130_fd_sc_hd__clkbuf_2
X_6276_ _2720_ _2737_ _2996_ _2472_ _3000_ VGND VGND VPWR VPWR _3001_ sky130_fd_sc_hd__a221o_1
X_9064_ clknet_leaf_102_CLK _0224_ VGND VGND VPWR VPWR regfile.registers\[26\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_8015_ _3137_ net928 _3974_ VGND VGND VPWR VPWR _3976_ sky130_fd_sc_hd__mux2_1
X_5227_ _1981_ _1982_ _1901_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__mux2_1
X_5158_ regfile.registers\[12\]\[30\] regfile.registers\[13\]\[30\] regfile.registers\[14\]\[30\]
+ regfile.registers\[15\]\[30\] _1881_ _1883_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__mux4_1
X_5089_ _1843_ _1844_ _1686_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__mux2_1
X_8917_ clknet_leaf_34_CLK _0077_ VGND VGND VPWR VPWR regfile.registers\[19\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8848_ clknet_leaf_11_CLK _0008_ VGND VGND VPWR VPWR regfile.registers\[5\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8779_ clknet_leaf_98_CLK _0963_ VGND VGND VPWR VPWR regfile.registers\[14\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_25_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_25_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_120_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4460_ _1197_ _1206_ _1212_ _1214_ _1215_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__o221a_1
Xclkbuf_leaf_16_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_16_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold307 regfile.registers\[19\]\[17\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4391_ _1146_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__clkbuf_4
Xhold329 regfile.registers\[25\]\[3\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
Xhold318 regfile.registers\[16\]\[4\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6130_ _2621_ _2856_ _2862_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__o21a_1
XFILLER_0_68_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_111_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6061_ _2737_ VGND VGND VPWR VPWR _2797_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_111_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1029 regfile.registers\[27\]\[22\] VGND VGND VPWR VPWR net1109 sky130_fd_sc_hd__dlygate4sd3_1
X_5012_ _1707_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__clkbuf_4
Xhold1018 regfile.registers\[15\]\[22\] VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1007 regfile.registers\[15\]\[20\] VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_77_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6963_ net454 _3141_ _3398_ VGND VGND VPWR VPWR _3402_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5914_ net109 VGND VGND VPWR VPWR _2658_ sky130_fd_sc_hd__buf_6
X_6894_ _3365_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8702_ clknet_leaf_74_CLK _0886_ VGND VGND VPWR VPWR regfile.registers\[15\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_124_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8633_ clknet_leaf_50_CLK _0817_ VGND VGND VPWR VPWR regfile.registers\[17\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_5845_ _1111_ _1125_ _1145_ _1166_ VGND VGND VPWR VPWR _2593_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_62_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8564_ net162 net32 _3006_ VGND VGND VPWR VPWR _4266_ sky130_fd_sc_hd__mux2_1
XFILLER_0_106_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5776_ _2363_ _2456_ _2526_ VGND VGND VPWR VPWR _2527_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_86_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8495_ _4230_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__clkbuf_1
X_7515_ _3699_ VGND VGND VPWR VPWR _3711_ sky130_fd_sc_hd__clkbuf_8
X_4727_ regfile.registers\[16\]\[14\] regfile.registers\[17\]\[14\] regfile.registers\[18\]\[14\]
+ regfile.registers\[19\]\[14\] _1324_ _1325_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7446_ _3674_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__clkbuf_1
X_4658_ _1078_ _1413_ _1057_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold830 regfile.registers\[14\]\[9\] VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__dlygate4sd3_1
Xhold841 regfile.registers\[23\]\[21\] VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlygate4sd3_1
Xhold852 regfile.registers\[22\]\[21\] VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4589_ regfile.registers\[0\]\[30\] regfile.registers\[1\]\[30\] regfile.registers\[2\]\[30\]
+ regfile.registers\[3\]\[30\] _1262_ _1263_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__mux4_1
X_9116_ clknet_leaf_43_CLK _0276_ VGND VGND VPWR VPWR regfile.registers\[27\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold863 regfile.registers\[15\]\[19\] VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__dlygate4sd3_1
X_7377_ _3637_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold896 regfile.registers\[14\]\[26\] VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6328_ _3038_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__clkbuf_1
Xhold874 regfile.registers\[23\]\[3\] VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__dlygate4sd3_1
Xhold885 regfile.registers\[16\]\[11\] VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__dlygate4sd3_1
X_9047_ clknet_leaf_34_CLK _0207_ VGND VGND VPWR VPWR regfile.registers\[31\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_110_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6259_ _1923_ _2983_ VGND VGND VPWR VPWR _2985_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_95_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_5_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_5_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_85_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5630_ _2383_ _2384_ VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5561_ _2315_ _2316_ _1711_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5492_ _1668_ _2247_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__nand2_1
X_4512_ _1202_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__buf_4
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7300_ _3033_ net964 _3591_ VGND VGND VPWR VPWR _3597_ sky130_fd_sc_hd__mux2_1
X_8280_ _4116_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_110_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold115 regfile.registers\[5\]\[0\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 regfile.registers\[10\]\[3\] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
X_7231_ _3559_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
Xhold126 regfile.registers\[6\]\[12\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_123_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_113_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold148 regfile.registers\[5\]\[27\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 regfile.registers\[19\]\[20\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
X_4443_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__buf_4
Xhold137 regfile.registers\[7\]\[8\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
X_4374_ regfile.registers\[16\]\[1\] regfile.registers\[17\]\[1\] regfile.registers\[18\]\[1\]
+ regfile.registers\[19\]\[1\] _1065_ _1066_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7162_ _3516_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_129_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6113_ _1781_ _1756_ VGND VGND VPWR VPWR _2847_ sky130_fd_sc_hd__and2_1
X_7093_ _3448_ VGND VGND VPWR VPWR _3471_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_1_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6044_ _2408_ _2775_ _2776_ _2781_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__o22a_1
XFILLER_0_119_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7995_ _3965_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_124_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6946_ net214 _3124_ _3387_ VGND VGND VPWR VPWR _3393_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6877_ _3356_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5828_ _2504_ _2564_ _2576_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__a21o_1
X_8616_ clknet_leaf_101_CLK _0800_ VGND VGND VPWR VPWR regfile.registers\[17\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_5759_ _2509_ _2510_ VGND VGND VPWR VPWR _2511_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8547_ _4257_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__clkbuf_1
X_8478_ _4221_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7429_ _3025_ net1011 _3664_ VGND VGND VPWR VPWR _3666_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold660 regfile.registers\[31\]\[30\] VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlygate4sd3_1
Xhold671 regfile.registers\[14\]\[31\] VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dlygate4sd3_1
Xhold693 regfile.registers\[4\]\[2\] VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlygate4sd3_1
Xhold682 regfile.registers\[12\]\[0\] VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6800_ _3315_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__clkbuf_1
X_4992_ _1712_ _1747_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__or2_1
X_7780_ _3851_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__clkbuf_1
X_6731_ net316 _3113_ _3278_ VGND VGND VPWR VPWR _3279_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6662_ _3230_ VGND VGND VPWR VPWR _3242_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9450_ clknet_leaf_0_CLK _0610_ VGND VGND VPWR VPWR regfile.registers\[13\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_128_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5613_ _1167_ _2063_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8401_ net588 _3512_ _4180_ VGND VGND VPWR VPWR _4181_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9381_ clknet_leaf_66_CLK _0541_ VGND VGND VPWR VPWR regfile.registers\[24\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_121_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6593_ _3193_ VGND VGND VPWR VPWR _3205_ sky130_fd_sc_hd__clkbuf_8
X_8332_ _4132_ VGND VGND VPWR VPWR _4144_ sky130_fd_sc_hd__clkbuf_8
X_5544_ _1716_ _2299_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8263_ _4107_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__clkbuf_1
X_5475_ regfile.registers\[24\]\[9\] regfile.registers\[25\]\[9\] regfile.registers\[26\]\[9\]
+ regfile.registers\[27\]\[9\] _1675_ _1692_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__mux4_1
X_7214_ net196 _3486_ _3491_ VGND VGND VPWR VPWR _3550_ sky130_fd_sc_hd__mux2_1
X_4426_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__buf_12
X_8194_ net330 _3510_ _4061_ VGND VGND VPWR VPWR _4071_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7145_ net372 _3504_ _3492_ VGND VGND VPWR VPWR _3505_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4357_ regfile.registers\[28\]\[2\] regfile.registers\[29\]\[2\] regfile.registers\[30\]\[2\]
+ regfile.registers\[31\]\[2\] _1052_ _1053_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__mux4_2
X_4288_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__buf_4
X_7076_ _3462_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
X_6027_ _2763_ _2765_ VGND VGND VPWR VPWR _2766_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_68_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7978_ _3956_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6929_ net153 _3107_ _3376_ VGND VGND VPWR VPWR _3384_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9579_ clknet_leaf_105_CLK _0739_ VGND VGND VPWR VPWR regfile.registers\[10\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold490 regfile.registers\[21\]\[9\] VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload35 clknet_leaf_21_CLK VGND VGND VPWR VPWR clkload35/Y sky130_fd_sc_hd__inv_6
XFILLER_0_70_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload24 clknet_leaf_10_CLK VGND VGND VPWR VPWR clkload24/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload13 clknet_leaf_7_CLK VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_125_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload46 clknet_leaf_33_CLK VGND VGND VPWR VPWR clkload46/Y sky130_fd_sc_hd__clkinv_4
Xclkload57 clknet_leaf_42_CLK VGND VGND VPWR VPWR clkload57/X sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload68 clknet_leaf_88_CLK VGND VGND VPWR VPWR clkload68/Y sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_121_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5260_ _1638_ _2015_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload79 clknet_leaf_66_CLK VGND VGND VPWR VPWR clkload79/Y sky130_fd_sc_hd__inv_8
XFILLER_0_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5191_ regfile.registers\[16\]\[28\] regfile.registers\[17\]\[28\] regfile.registers\[18\]\[28\]
+ regfile.registers\[19\]\[28\] _1882_ _1884_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__mux4_1
X_8950_ clknet_leaf_52_CLK _0110_ VGND VGND VPWR VPWR regfile.registers\[3\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7901_ _3588_ _3662_ VGND VGND VPWR VPWR _3915_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_108_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8881_ clknet_leaf_14_CLK _0041_ VGND VGND VPWR VPWR regfile.registers\[4\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_19_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7832_ _3878_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_121_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4975_ _1672_ _1698_ _1715_ _1730_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__a2bb2o_2
X_7763_ _3087_ net955 _3807_ VGND VGND VPWR VPWR _3842_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6714_ net800 _3097_ _3267_ VGND VGND VPWR VPWR _3270_ sky130_fd_sc_hd__mux2_1
X_9502_ clknet_leaf_73_CLK _0662_ VGND VGND VPWR VPWR regfile.registers\[12\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9433_ clknet_leaf_48_CLK _0593_ VGND VGND VPWR VPWR regfile.registers\[1\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_7694_ _3805_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6645_ _3233_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__clkbuf_1
Xclkload7 clknet_leaf_0_CLK VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__clkinvlp_2
X_9364_ clknet_leaf_23_CLK _0524_ VGND VGND VPWR VPWR regfile.registers\[20\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_6576_ _3196_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_119_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8315_ _4135_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__clkbuf_1
X_9295_ clknet_leaf_1_CLK _0455_ VGND VGND VPWR VPWR regfile.registers\[25\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_5527_ regfile.registers\[0\]\[7\] regfile.registers\[1\]\[7\] regfile.registers\[2\]\[7\]
+ regfile.registers\[3\]\[7\] _2117_ _2118_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__mux4_1
XFILLER_0_100_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8246_ _3095_ net1071 _4097_ VGND VGND VPWR VPWR _4099_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5458_ regfile.registers\[20\]\[8\] regfile.registers\[21\]\[8\] regfile.registers\[22\]\[8\]
+ regfile.registers\[23\]\[8\] _2051_ _2053_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__mux4_1
X_5389_ regfile.registers\[20\]\[13\] regfile.registers\[21\]\[13\] regfile.registers\[22\]\[13\]
+ regfile.registers\[23\]\[13\] _1673_ _1690_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__mux4_1
X_8177_ _4062_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__clkbuf_1
X_4409_ _1088_ _1164_ net8 VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7128_ _3493_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
X_7059_ _3453_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_83_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4760_ regfile.registers\[28\]\[8\] regfile.registers\[29\]\[8\] regfile.registers\[30\]\[8\]
+ regfile.registers\[31\]\[8\] _1026_ _1061_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__mux4_1
XFILLER_0_56_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4691_ _1430_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6430_ _3108_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__clkbuf_1
Xclkload102 clknet_leaf_63_CLK VGND VGND VPWR VPWR clkload102/Y sky130_fd_sc_hd__clkinv_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6361_ _3060_ net770 _3044_ VGND VGND VPWR VPWR _3061_ sky130_fd_sc_hd__mux2_1
X_8100_ net730 _3484_ _4011_ VGND VGND VPWR VPWR _4021_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5312_ regfile.registers\[28\]\[2\] regfile.registers\[29\]\[2\] regfile.registers\[30\]\[2\]
+ regfile.registers\[31\]\[2\] _1701_ _1677_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__mux4_1
XFILLER_0_24_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6292_ net37 VGND VGND VPWR VPWR _3013_ sky130_fd_sc_hd__clkbuf_4
X_9080_ clknet_leaf_21_CLK _0240_ VGND VGND VPWR VPWR regfile.registers\[26\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8031_ _3013_ net855 _3974_ VGND VGND VPWR VPWR _3984_ sky130_fd_sc_hd__mux2_1
X_5243_ _1980_ _1998_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__or2_1
X_5174_ regfile.registers\[28\]\[29\] regfile.registers\[29\]\[29\] regfile.registers\[30\]\[29\]
+ regfile.registers\[31\]\[29\] _1705_ _1708_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8933_ clknet_leaf_93_CLK _0093_ VGND VGND VPWR VPWR regfile.registers\[3\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_8864_ clknet_leaf_73_CLK _0024_ VGND VGND VPWR VPWR regfile.registers\[4\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_7815_ net276 _3540_ _3866_ VGND VGND VPWR VPWR _3870_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8795_ clknet_leaf_39_CLK _0979_ VGND VGND VPWR VPWR regfile.registers\[14\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_65_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4958_ _1709_ _1710_ _1713_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__mux2_1
X_7746_ _3833_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7677_ net189 _3538_ _3794_ VGND VGND VPWR VPWR _3797_ sky130_fd_sc_hd__mux2_1
X_4889_ net3 VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__inv_2
XFILLER_0_116_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6628_ _3223_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9416_ clknet_leaf_96_CLK _0576_ VGND VGND VPWR VPWR regfile.registers\[1\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9347_ clknet_leaf_80_CLK _0507_ VGND VGND VPWR VPWR regfile.registers\[20\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_6559_ _3185_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9278_ clknet_leaf_73_CLK _0438_ VGND VGND VPWR VPWR regfile.registers\[25\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_8229_ _4089_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_106_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_115_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5930_ _2212_ _2429_ VGND VGND VPWR VPWR _2674_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_124_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5861_ _2457_ _2525_ _1877_ VGND VGND VPWR VPWR _2608_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7600_ _3060_ net741 _3747_ VGND VGND VPWR VPWR _3756_ sky130_fd_sc_hd__mux2_1
X_5792_ _2509_ _2541_ _2517_ VGND VGND VPWR VPWR _2542_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4812_ regfile.registers\[4\]\[11\] regfile.registers\[5\]\[11\] regfile.registers\[6\]\[11\]
+ regfile.registers\[7\]\[11\] net99 _1090_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__mux4_1
X_8580_ clknet_leaf_92_CLK _0764_ VGND VGND VPWR VPWR regfile.registers\[23\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4743_ regfile.registers\[28\]\[15\] regfile.registers\[29\]\[15\] regfile.registers\[30\]\[15\]
+ regfile.registers\[31\]\[15\] _1262_ _1263_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7531_ _3719_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7462_ _3058_ net859 _3675_ VGND VGND VPWR VPWR _3683_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4674_ _1239_ _1421_ _1425_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__a2bb2o_2
X_9201_ clknet_leaf_4_CLK _0361_ VGND VGND VPWR VPWR regfile.registers\[30\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6413_ net38 VGND VGND VPWR VPWR _3097_ sky130_fd_sc_hd__buf_2
XFILLER_0_31_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7393_ _3058_ net601 _3638_ VGND VGND VPWR VPWR _3646_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9132_ clknet_leaf_108_CLK _0292_ VGND VGND VPWR VPWR regfile.registers\[28\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_6344_ _3049_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__clkbuf_1
X_6275_ _2530_ _2859_ _2999_ _1087_ VGND VGND VPWR VPWR _3000_ sky130_fd_sc_hd__o211a_1
X_9063_ clknet_leaf_61_CLK _0223_ VGND VGND VPWR VPWR regfile.registers\[26\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_8014_ _3975_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__clkbuf_1
X_5226_ regfile.registers\[16\]\[26\] regfile.registers\[17\]\[26\] regfile.registers\[18\]\[26\]
+ regfile.registers\[19\]\[26\] _1881_ _1883_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__mux4_1
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5157_ regfile.registers\[8\]\[30\] regfile.registers\[9\]\[30\] regfile.registers\[10\]\[30\]
+ regfile.registers\[11\]\[30\] _1881_ _1883_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__mux4_1
X_5088_ regfile.registers\[16\]\[17\] regfile.registers\[17\]\[17\] regfile.registers\[18\]\[17\]
+ regfile.registers\[19\]\[17\] _1689_ _1693_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__mux4_1
X_8916_ clknet_leaf_23_CLK _0076_ VGND VGND VPWR VPWR regfile.registers\[19\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8847_ clknet_leaf_7_CLK _0007_ VGND VGND VPWR VPWR regfile.registers\[5\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8778_ clknet_leaf_0_CLK _0962_ VGND VGND VPWR VPWR regfile.registers\[14\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7729_ _3824_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold308 regfile.registers\[18\]\[8\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4390_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__clkbuf_4
Xhold319 regfile.registers\[3\]\[8\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6060_ _2585_ _2578_ _2426_ VGND VGND VPWR VPWR _2796_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_111_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5011_ _1704_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__buf_4
Xhold1019 regfile.registers\[28\]\[31\] VGND VGND VPWR VPWR net1099 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1008 regfile.registers\[22\]\[5\] VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__dlygate4sd3_1
X_6962_ _3401_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
X_6893_ net461 _3139_ _3362_ VGND VGND VPWR VPWR _3365_ sky130_fd_sc_hd__mux2_1
X_5913_ _1416_ _1573_ _2506_ _2535_ VGND VGND VPWR VPWR _2657_ sky130_fd_sc_hd__and4b_1
X_8701_ clknet_leaf_44_CLK _0885_ VGND VGND VPWR VPWR regfile.registers\[0\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_24_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5844_ _2038_ _2590_ _2591_ _2253_ VGND VGND VPWR VPWR _2592_ sky130_fd_sc_hd__a2bb2o_1
X_8632_ clknet_leaf_17_CLK _0816_ VGND VGND VPWR VPWR regfile.registers\[17\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_62_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8563_ _4265_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5775_ _2327_ _2525_ VGND VGND VPWR VPWR _2526_ sky130_fd_sc_hd__nand2_1
X_7514_ _3710_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
X_8494_ net1134 net30 _4227_ VGND VGND VPWR VPWR _4230_ sky130_fd_sc_hd__mux2_1
X_4726_ regfile.registers\[28\]\[14\] regfile.registers\[29\]\[14\] regfile.registers\[30\]\[14\]
+ regfile.registers\[31\]\[14\] _1324_ _1325_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__mux4_1
X_7445_ _3041_ net1051 _3664_ VGND VGND VPWR VPWR _3674_ sky130_fd_sc_hd__mux2_1
X_4657_ _1411_ _1412_ _1040_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7376_ _3041_ net367 _3627_ VGND VGND VPWR VPWR _3637_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold820 regfile.registers\[3\]\[14\] VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__dlygate4sd3_1
Xhold864 regfile.registers\[29\]\[28\] VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__dlygate4sd3_1
X_9115_ clknet_leaf_26_CLK _0275_ VGND VGND VPWR VPWR regfile.registers\[27\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_4588_ regfile.registers\[4\]\[30\] regfile.registers\[5\]\[30\] regfile.registers\[6\]\[30\]
+ regfile.registers\[7\]\[30\] _1262_ _1263_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__mux4_1
X_6327_ _3037_ net689 _3023_ VGND VGND VPWR VPWR _3038_ sky130_fd_sc_hd__mux2_1
Xhold853 regfile.registers\[27\]\[14\] VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__dlygate4sd3_1
Xhold831 regfile.registers\[30\]\[1\] VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dlygate4sd3_1
Xhold842 regfile.registers\[16\]\[6\] VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold875 regfile.registers\[30\]\[31\] VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__dlygate4sd3_1
Xhold897 regfile.registers\[18\]\[19\] VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dlygate4sd3_1
Xhold886 regfile.registers\[3\]\[7\] VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dlygate4sd3_1
X_9046_ clknet_leaf_36_CLK _0206_ VGND VGND VPWR VPWR regfile.registers\[31\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_110_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6258_ _1923_ _2983_ VGND VGND VPWR VPWR _2984_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_73_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6189_ _2916_ _2917_ VGND VGND VPWR VPWR _2918_ sky130_fd_sc_hd__and2_1
X_5209_ _1963_ _1964_ _1745_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5560_ regfile.registers\[12\]\[5\] regfile.registers\[13\]\[5\] regfile.registers\[14\]\[5\]
+ regfile.registers\[15\]\[5\] _1718_ _1721_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__mux4_1
X_5491_ _1842_ _2246_ VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__nor2_1
X_4511_ _1200_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__buf_8
Xhold116 regfile.registers\[3\]\[30\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
X_4442_ _1040_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__buf_4
X_7230_ net170 _3502_ _3553_ VGND VGND VPWR VPWR _3559_ sky130_fd_sc_hd__mux2_1
Xhold105 regfile.registers\[1\]\[14\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_113_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold138 regfile.registers\[19\]\[28\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 regfile.registers\[12\]\[31\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold149 regfile.registers\[9\]\[15\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
X_4373_ regfile.registers\[20\]\[1\] regfile.registers\[21\]\[1\] regfile.registers\[22\]\[1\]
+ regfile.registers\[23\]\[1\] _1065_ _1066_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7161_ net1021 _3515_ _3513_ VGND VGND VPWR VPWR _3516_ sky130_fd_sc_hd__mux2_1
X_6112_ _2102_ _2554_ VGND VGND VPWR VPWR _2846_ sky130_fd_sc_hd__nor2_1
X_7092_ _3470_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6043_ _2625_ _2731_ _2779_ _2496_ _2780_ VGND VGND VPWR VPWR _2781_ sky130_fd_sc_hd__a221o_1
XFILLER_0_89_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7994_ _3116_ net411 _3963_ VGND VGND VPWR VPWR _3965_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_124_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6945_ _3392_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6876_ net772 _3122_ _3351_ VGND VGND VPWR VPWR _3356_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5827_ _2496_ _2569_ _2572_ _2468_ _2575_ VGND VGND VPWR VPWR _2576_ sky130_fd_sc_hd__a221o_1
X_8615_ clknet_leaf_62_CLK _0799_ VGND VGND VPWR VPWR regfile.registers\[17\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5758_ _2305_ _2508_ VGND VGND VPWR VPWR _2510_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8546_ net345 net22 _4255_ VGND VGND VPWR VPWR _4257_ sky130_fd_sc_hd__mux2_1
X_4709_ regfile.registers\[20\]\[13\] regfile.registers\[21\]\[13\] regfile.registers\[22\]\[13\]
+ regfile.registers\[23\]\[13\] net1147 _1029_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__mux4_1
X_8477_ net518 net21 _4216_ VGND VGND VPWR VPWR _4221_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5689_ _1961_ _1999_ _2347_ VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__mux2_1
X_7428_ _3665_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold650 regfile.registers\[20\]\[29\] VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlygate4sd3_1
Xhold672 regfile.registers\[4\]\[0\] VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dlygate4sd3_1
X_7359_ _3628_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
Xhold661 regfile.registers\[28\]\[18\] VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlygate4sd3_1
Xhold694 regfile.registers\[14\]\[30\] VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlygate4sd3_1
Xhold683 regfile.registers\[8\]\[16\] VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dlygate4sd3_1
X_9029_ clknet_leaf_66_CLK _0189_ VGND VGND VPWR VPWR regfile.registers\[31\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_86_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4991_ regfile.registers\[8\]\[22\] regfile.registers\[9\]\[22\] regfile.registers\[10\]\[22\]
+ regfile.registers\[11\]\[22\] _1704_ _1707_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__mux4_1
XFILLER_0_81_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6730_ _3266_ VGND VGND VPWR VPWR _3278_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6661_ _3241_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__clkbuf_1
X_5612_ _1167_ _2081_ VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__or2_1
X_6592_ _3204_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__clkbuf_1
X_8400_ _4168_ VGND VGND VPWR VPWR _4180_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_14_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9380_ clknet_leaf_91_CLK _0540_ VGND VGND VPWR VPWR regfile.registers\[24\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_8331_ _4143_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5543_ _2297_ _2298_ _1738_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5474_ _1639_ _2229_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__or2_1
X_8262_ _3111_ net847 _4097_ VGND VGND VPWR VPWR _4107_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7213_ _3549_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
X_8193_ _4070_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_57_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4425_ _1042_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__buf_12
X_4356_ regfile.registers\[24\]\[2\] regfile.registers\[25\]\[2\] regfile.registers\[26\]\[2\]
+ regfile.registers\[27\]\[2\] _1042_ _1044_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__mux4_2
X_7144_ net44 VGND VGND VPWR VPWR _3504_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7075_ net1003 _3116_ _3460_ VGND VGND VPWR VPWR _3462_ sky130_fd_sc_hd__mux2_1
X_4287_ A2[1] VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__buf_4
X_6026_ _2744_ _2749_ _2764_ VGND VGND VPWR VPWR _2765_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7977_ _3099_ net938 _3952_ VGND VGND VPWR VPWR _3956_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6928_ _3383_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_81_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6859_ net165 _3105_ _3340_ VGND VGND VPWR VPWR _3347_ sky130_fd_sc_hd__mux2_1
XFILLER_0_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9578_ clknet_leaf_105_CLK _0738_ VGND VGND VPWR VPWR regfile.registers\[10\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8529_ net174 net45 _4244_ VGND VGND VPWR VPWR _4248_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_754 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold480 regfile.registers\[29\]\[27\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold491 regfile.registers\[15\]\[18\] VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload14 clknet_leaf_18_CLK VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__bufinv_16
Xclkload25 clknet_leaf_12_CLK VGND VGND VPWR VPWR clkload25/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload36 clknet_leaf_22_CLK VGND VGND VPWR VPWR clkload36/Y sky130_fd_sc_hd__inv_6
Xclkload58 clknet_leaf_43_CLK VGND VGND VPWR VPWR clkload58/Y sky130_fd_sc_hd__bufinv_16
Xclkload47 clknet_leaf_13_CLK VGND VGND VPWR VPWR clkload47/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload69 clknet_leaf_89_CLK VGND VGND VPWR VPWR clkload69/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_121_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5190_ regfile.registers\[28\]\[28\] regfile.registers\[29\]\[28\] regfile.registers\[30\]\[28\]
+ regfile.registers\[31\]\[28\] _1882_ _1884_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__mux4_1
XFILLER_0_76_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7900_ _3914_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_108_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8880_ clknet_leaf_11_CLK _0040_ VGND VGND VPWR VPWR regfile.registers\[4\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_19_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7831_ net827 _3488_ _3843_ VGND VGND VPWR VPWR _3878_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_121_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4974_ _1717_ _1727_ _1729_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__a21oi_1
X_7762_ _3841_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7693_ net487 _3486_ _3771_ VGND VGND VPWR VPWR _3805_ sky130_fd_sc_hd__mux2_1
X_9501_ clknet_leaf_61_CLK _0661_ VGND VGND VPWR VPWR regfile.registers\[16\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_6713_ _3269_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9432_ clknet_leaf_15_CLK _0592_ VGND VGND VPWR VPWR regfile.registers\[1\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6644_ _3025_ net1020 _3231_ VGND VGND VPWR VPWR _3233_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload8 clknet_leaf_1_CLK VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__clkinvlp_2
X_9363_ clknet_leaf_28_CLK _0523_ VGND VGND VPWR VPWR regfile.registers\[20\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6575_ net750 _3095_ _3194_ VGND VGND VPWR VPWR _3196_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_119_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5526_ regfile.registers\[4\]\[7\] regfile.registers\[5\]\[7\] regfile.registers\[6\]\[7\]
+ regfile.registers\[7\]\[7\] _2117_ _2118_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__mux4_1
X_8314_ net1096 _3494_ _4133_ VGND VGND VPWR VPWR _4135_ sky130_fd_sc_hd__mux2_1
X_9294_ clknet_leaf_5_CLK _0454_ VGND VGND VPWR VPWR regfile.registers\[25\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_5457_ _1169_ _2194_ _2212_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_42_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8245_ _4098_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4408_ _1162_ _1163_ _1035_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5388_ _1638_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__inv_2
X_8176_ net298 _3490_ _4061_ VGND VGND VPWR VPWR _4062_ sky130_fd_sc_hd__mux2_1
X_4339_ regfile.registers\[28\]\[3\] regfile.registers\[29\]\[3\] regfile.registers\[30\]\[3\]
+ regfile.registers\[31\]\[3\] net99 _1090_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__mux4_1
X_7127_ net342 _3490_ _3492_ VGND VGND VPWR VPWR _3493_ sky130_fd_sc_hd__mux2_1
X_7058_ net1014 _3099_ _3449_ VGND VGND VPWR VPWR _3453_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6009_ _2668_ net107 _2748_ VGND VGND VPWR VPWR _2749_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_96_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4690_ _1239_ _1437_ _1445_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_102_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload103 clknet_leaf_67_CLK VGND VGND VPWR VPWR clkload103/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6360_ net25 VGND VGND VPWR VPWR _3060_ sky130_fd_sc_hd__clkbuf_2
X_5311_ _2065_ _2066_ _1645_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__mux2_1
X_6291_ _3012_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__clkbuf_1
X_8030_ _3983_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5242_ _1839_ _1997_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__nor2_1
X_5173_ _1927_ _1928_ _1745_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput1 A1[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__dlymetal6s2s_1
X_8932_ clknet_leaf_64_CLK _0092_ VGND VGND VPWR VPWR regfile.registers\[3\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_8863_ clknet_leaf_74_CLK _0023_ VGND VGND VPWR VPWR regfile.registers\[4\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_7814_ _3869_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__clkbuf_1
X_8794_ clknet_leaf_23_CLK _0978_ VGND VGND VPWR VPWR regfile.registers\[14\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_65_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7745_ _3069_ net962 _3830_ VGND VGND VPWR VPWR _3833_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4957_ _1712_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__clkbuf_8
X_7676_ _3796_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
X_4888_ regfile.registers\[16\]\[0\] regfile.registers\[17\]\[0\] regfile.registers\[18\]\[0\]
+ regfile.registers\[19\]\[0\] _1641_ _1642_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__mux4_1
XFILLER_0_117_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6627_ net480 _3002_ _3216_ VGND VGND VPWR VPWR _3223_ sky130_fd_sc_hd__mux2_1
X_9415_ clknet_leaf_57_CLK _0575_ VGND VGND VPWR VPWR regfile.registers\[1\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6558_ _3079_ net540 _3177_ VGND VGND VPWR VPWR _3185_ sky130_fd_sc_hd__mux2_1
X_9346_ clknet_leaf_85_CLK _0506_ VGND VGND VPWR VPWR regfile.registers\[20\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6489_ net187 _3009_ _3135_ VGND VGND VPWR VPWR _3148_ sky130_fd_sc_hd__mux2_1
X_9277_ clknet_leaf_12_CLK _0437_ VGND VGND VPWR VPWR regfile.registers\[18\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_5509_ _2263_ _2264_ _1712_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__mux2_1
X_8228_ net201 _3544_ _4083_ VGND VGND VPWR VPWR _4089_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8159_ _4052_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5860_ _2504_ _2604_ _2606_ VGND VGND VPWR VPWR _2607_ sky130_fd_sc_hd__or3_1
X_4811_ _1071_ _1566_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__nand2_1
X_5791_ _2323_ _2515_ VGND VGND VPWR VPWR _2541_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4742_ _1496_ _1497_ _1259_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7530_ _3058_ net1054 _3711_ VGND VGND VPWR VPWR _3719_ sky130_fd_sc_hd__mux2_1
X_4673_ _1254_ _1428_ _1170_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7461_ _3682_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6412_ _3096_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__clkbuf_1
X_9200_ clknet_leaf_7_CLK _0360_ VGND VGND VPWR VPWR regfile.registers\[30\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7392_ _3645_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6343_ _3048_ net1073 _3044_ VGND VGND VPWR VPWR _3049_ sky130_fd_sc_hd__mux2_1
X_9131_ clknet_leaf_103_CLK _0291_ VGND VGND VPWR VPWR regfile.registers\[28\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_6274_ _2254_ _2925_ _2998_ _2337_ VGND VGND VPWR VPWR _2999_ sky130_fd_sc_hd__o22a_1
X_9062_ clknet_leaf_68_CLK _0222_ VGND VGND VPWR VPWR regfile.registers\[26\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8013_ _3134_ net197 _3974_ VGND VGND VPWR VPWR _3975_ sky130_fd_sc_hd__mux2_1
X_5225_ regfile.registers\[20\]\[26\] regfile.registers\[21\]\[26\] regfile.registers\[22\]\[26\]
+ regfile.registers\[23\]\[26\] _1881_ _1883_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_111_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_111_CLK
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5156_ _1908_ _1911_ _1700_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5087_ regfile.registers\[20\]\[17\] regfile.registers\[21\]\[17\] regfile.registers\[22\]\[17\]
+ regfile.registers\[23\]\[17\] _1689_ _1693_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__mux4_1
X_8915_ clknet_leaf_28_CLK _0075_ VGND VGND VPWR VPWR regfile.registers\[19\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8846_ clknet_leaf_5_CLK _0006_ VGND VGND VPWR VPWR regfile.registers\[5\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5989_ _2716_ _2722_ _2729_ _2621_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__o22a_1
XFILLER_0_59_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8777_ clknet_leaf_98_CLK _0961_ VGND VGND VPWR VPWR regfile.registers\[14\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_7728_ _3052_ net736 _3819_ VGND VGND VPWR VPWR _3824_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7659_ _3787_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9329_ clknet_leaf_18_CLK _0489_ VGND VGND VPWR VPWR regfile.registers\[21\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_102_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_102_CLK
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_89_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold309 regfile.registers\[1\]\[17\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5010_ _1700_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_111_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1009 regfile.registers\[1\]\[4\] VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6961_ net887 _3139_ _3398_ VGND VGND VPWR VPWR _3401_ sky130_fd_sc_hd__mux2_1
X_8700_ clknet_leaf_45_CLK _0884_ VGND VGND VPWR VPWR regfile.registers\[0\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_124_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6892_ _3364_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__clkbuf_1
X_5912_ _2504_ _2647_ _2653_ _2656_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_24_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8631_ clknet_leaf_36_CLK _0815_ VGND VGND VPWR VPWR regfile.registers\[17\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5843_ _2039_ _2102_ VGND VGND VPWR VPWR _2591_ sky130_fd_sc_hd__nor2_4
XFILLER_0_76_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8562_ net361 net31 _4255_ VGND VGND VPWR VPWR _4265_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5774_ _2369_ _2360_ VGND VGND VPWR VPWR _2525_ sky130_fd_sc_hd__nand2_1
X_7513_ _3041_ net413 _3700_ VGND VGND VPWR VPWR _3710_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8493_ _4229_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4725_ regfile.registers\[24\]\[14\] regfile.registers\[25\]\[14\] regfile.registers\[26\]\[14\]
+ regfile.registers\[27\]\[14\] _1324_ _1325_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__mux4_1
X_7444_ _3673_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__clkbuf_1
X_4656_ regfile.registers\[0\]\[7\] regfile.registers\[1\]\[7\] regfile.registers\[2\]\[7\]
+ regfile.registers\[3\]\[7\] _1290_ _1193_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__mux4_1
Xhold810 regfile.registers\[13\]\[28\] VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__dlygate4sd3_1
X_4587_ _1211_ _1342_ _1078_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__a21o_1
X_7375_ _3636_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold821 regfile.registers\[30\]\[3\] VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__dlygate4sd3_1
Xhold843 regfile.registers\[15\]\[23\] VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dlygate4sd3_1
X_9114_ clknet_leaf_24_CLK _0274_ VGND VGND VPWR VPWR regfile.registers\[27\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold854 regfile.registers\[26\]\[12\] VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__dlygate4sd3_1
Xhold832 regfile.registers\[27\]\[7\] VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dlygate4sd3_1
X_6326_ net45 VGND VGND VPWR VPWR _3037_ sky130_fd_sc_hd__buf_2
Xhold876 regfile.registers\[19\]\[31\] VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold898 regfile.registers\[31\]\[2\] VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__dlygate4sd3_1
Xhold887 regfile.registers\[26\]\[14\] VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__dlygate4sd3_1
Xhold865 regfile.registers\[24\]\[15\] VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dlygate4sd3_1
X_9045_ clknet_leaf_29_CLK _0205_ VGND VGND VPWR VPWR regfile.registers\[31\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_6257_ net102 _2982_ VGND VGND VPWR VPWR _2983_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_73_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6188_ _1978_ _2915_ VGND VGND VPWR VPWR _2917_ sky130_fd_sc_hd__nand2_1
X_5208_ regfile.registers\[16\]\[27\] regfile.registers\[17\]\[27\] regfile.registers\[18\]\[27\]
+ regfile.registers\[19\]\[27\] _1767_ _1768_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__mux4_1
X_5139_ _1689_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_4_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8829_ clknet_leaf_43_CLK _1013_ VGND VGND VPWR VPWR regfile.registers\[6\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4510_ _1260_ _1265_ _1187_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__mux2_2
XFILLER_0_79_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5490_ _1671_ _2237_ _2245_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_26_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold106 regfile.registers\[19\]\[27\] VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4441_ _1190_ _1196_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__and2_1
Xhold117 regfile.registers\[21\]\[20\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold128 regfile.registers\[7\]\[9\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold139 regfile.registers\[18\]\[13\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
X_7160_ net18 VGND VGND VPWR VPWR _3515_ sky130_fd_sc_hd__buf_2
X_6111_ _2840_ _2844_ VGND VGND VPWR VPWR _2845_ sky130_fd_sc_hd__xor2_1
XFILLER_0_95_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4372_ _1087_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__nand2_1
X_7091_ net638 _3132_ _3460_ VGND VGND VPWR VPWR _3470_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6042_ _2420_ _2738_ _2333_ VGND VGND VPWR VPWR _2780_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7993_ _3964_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_124_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6944_ net167 _3122_ _3387_ VGND VGND VPWR VPWR _3392_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8614_ clknet_leaf_70_CLK _0798_ VGND VGND VPWR VPWR regfile.registers\[17\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6875_ _3355_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5826_ _2105_ _2573_ _2574_ _2373_ VGND VGND VPWR VPWR _2575_ sky130_fd_sc_hd__o211a_1
XFILLER_0_91_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5757_ _2305_ _2508_ VGND VGND VPWR VPWR _2509_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8545_ _4256_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_115_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8476_ _4220_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__clkbuf_1
X_4708_ _1455_ _1215_ _1463_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_44_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5688_ _1926_ _2178_ VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__or2b_1
XFILLER_0_71_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7427_ _3019_ net1005 _3664_ VGND VGND VPWR VPWR _3665_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_9_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4639_ regfile.registers\[4\]\[6\] regfile.registers\[5\]\[6\] regfile.registers\[6\]\[6\]
+ regfile.registers\[7\]\[6\] net97 _1073_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__mux4_1
Xhold662 regfile.registers\[28\]\[27\] VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dlygate4sd3_1
Xhold640 regfile.registers\[27\]\[28\] VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlygate4sd3_1
X_7358_ _3019_ net867 _3627_ VGND VGND VPWR VPWR _3628_ sky130_fd_sc_hd__mux2_1
Xhold651 regfile.registers\[7\]\[6\] VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dlygate4sd3_1
Xhold684 regfile.registers\[4\]\[31\] VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dlygate4sd3_1
X_7289_ _3590_ VGND VGND VPWR VPWR _3591_ sky130_fd_sc_hd__clkbuf_8
X_6309_ _3025_ net700 _3023_ VGND VGND VPWR VPWR _3026_ sky130_fd_sc_hd__mux2_1
Xhold673 regfile.registers\[8\]\[1\] VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dlygate4sd3_1
Xhold695 regfile.registers\[24\]\[17\] VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dlygate4sd3_1
X_9028_ clknet_leaf_92_CLK _0188_ VGND VGND VPWR VPWR regfile.registers\[31\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_86_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_128_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4990_ regfile.registers\[12\]\[22\] regfile.registers\[13\]\[22\] regfile.registers\[14\]\[22\]
+ regfile.registers\[15\]\[22\] _1720_ _1723_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6660_ _3041_ net628 _3231_ VGND VGND VPWR VPWR _3241_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5611_ _2365_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__inv_2
X_6591_ net146 _3111_ _3194_ VGND VGND VPWR VPWR _3204_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8330_ net634 _3510_ _4133_ VGND VGND VPWR VPWR _4143_ sky130_fd_sc_hd__mux2_1
X_5542_ regfile.registers\[8\]\[4\] regfile.registers\[9\]\[4\] regfile.registers\[10\]\[4\]
+ regfile.registers\[11\]\[4\] _1718_ _1721_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__mux4_1
XFILLER_0_26_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_91_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_91_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8261_ _4106_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__clkbuf_1
X_5473_ _1671_ _2220_ _2224_ _2228_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_112_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4424_ regfile.registers\[28\]\[29\] regfile.registers\[29\]\[29\] regfile.registers\[30\]\[29\]
+ regfile.registers\[31\]\[29\] _1173_ _1175_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__mux4_1
X_7212_ net483 _3484_ _3534_ VGND VGND VPWR VPWR _3549_ sky130_fd_sc_hd__mux2_1
X_8192_ net264 _3508_ _4061_ VGND VGND VPWR VPWR _4070_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4355_ _1110_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7143_ _3503_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_70_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7074_ _3461_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_4286_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__buf_12
Xclkbuf_3_0__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_0__leaf_CLK sky130_fd_sc_hd__clkbuf_16
X_6025_ _1874_ _2743_ VGND VGND VPWR VPWR _2764_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7976_ _3955_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6927_ net122 _3105_ _3376_ VGND VGND VPWR VPWR _3383_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6858_ _3346_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5809_ _1415_ _2557_ VGND VGND VPWR VPWR _2558_ sky130_fd_sc_hd__xor2_1
XFILLER_0_9_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9577_ clknet_leaf_99_CLK _0737_ VGND VGND VPWR VPWR regfile.registers\[10\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_6789_ _3309_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__clkbuf_1
X_8528_ _4247_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_82_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_82_CLK sky130_fd_sc_hd__clkbuf_8
X_8459_ _4211_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold481 regfile.registers\[17\]\[14\] VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd3_1
Xhold470 regfile.registers\[7\]\[17\] VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlygate4sd3_1
Xhold492 regfile.registers\[12\]\[13\] VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_95_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload15 clknet_leaf_19_CLK VGND VGND VPWR VPWR clkload15/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_63_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_73_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_73_CLK sky130_fd_sc_hd__clkbuf_8
Xclkload26 clknet_leaf_97_CLK VGND VGND VPWR VPWR clkload26/Y sky130_fd_sc_hd__clkinv_1
XFILLER_0_106_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload37 clknet_leaf_24_CLK VGND VGND VPWR VPWR clkload37/Y sky130_fd_sc_hd__inv_6
Xclkload48 clknet_leaf_15_CLK VGND VGND VPWR VPWR clkload48/Y sky130_fd_sc_hd__clkinv_4
Xclkload59 clknet_leaf_44_CLK VGND VGND VPWR VPWR clkload59/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7830_ _3877_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_121_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7761_ _3085_ net749 _3807_ VGND VGND VPWR VPWR _3841_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4973_ _1728_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__clkbuf_8
X_7692_ _3804_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_1
X_9500_ clknet_leaf_46_CLK _0660_ VGND VGND VPWR VPWR regfile.registers\[16\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6712_ net753 _3095_ _3267_ VGND VGND VPWR VPWR _3269_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9431_ clknet_leaf_51_CLK _0591_ VGND VGND VPWR VPWR regfile.registers\[1\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_6643_ _3232_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload9 clknet_leaf_2_CLK VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__clkinv_4
X_9362_ clknet_leaf_47_CLK _0522_ VGND VGND VPWR VPWR regfile.registers\[20\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_64_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_64_CLK sky130_fd_sc_hd__clkbuf_8
X_6574_ _3195_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_119_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8313_ _4134_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__clkbuf_1
X_9293_ clknet_leaf_95_CLK _0453_ VGND VGND VPWR VPWR regfile.registers\[25\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_5525_ _1699_ _2280_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__nand2_1
X_5456_ _1168_ _2211_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8244_ _3089_ net925 _4097_ VGND VGND VPWR VPWR _4098_ sky130_fd_sc_hd__mux2_1
X_4407_ regfile.registers\[0\]\[0\] regfile.registers\[1\]\[0\] regfile.registers\[2\]\[0\]
+ regfile.registers\[3\]\[0\] net87 _1061_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__mux4_1
X_5387_ _1169_ _2124_ _2142_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__o21ba_1
X_8175_ _4060_ VGND VGND VPWR VPWR _4061_ sky130_fd_sc_hd__clkbuf_8
X_7126_ _3491_ VGND VGND VPWR VPWR _3492_ sky130_fd_sc_hd__clkbuf_8
X_4338_ _1088_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__nand2_1
X_7057_ _3452_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_4269_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__clkbuf_8
X_6008_ _2123_ net106 _2746_ _2747_ VGND VGND VPWR VPWR _2748_ sky130_fd_sc_hd__o211a_1
X_7959_ _3009_ net734 _3938_ VGND VGND VPWR VPWR _3946_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_55_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_55_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_122_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_46_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_46_CLK sky130_fd_sc_hd__clkbuf_8
Xclkload104 clknet_leaf_68_CLK VGND VGND VPWR VPWR clkload104/Y sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_36_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6290_ net261 _3011_ _3007_ VGND VGND VPWR VPWR _3012_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5310_ regfile.registers\[16\]\[2\] regfile.registers\[17\]\[2\] regfile.registers\[18\]\[2\]
+ regfile.registers\[19\]\[2\] _1701_ _1677_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__mux4_1
XFILLER_0_87_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5241_ _1842_ _1996_ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__nor2_2
XFILLER_0_11_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5172_ regfile.registers\[16\]\[29\] regfile.registers\[17\]\[29\] regfile.registers\[18\]\[29\]
+ regfile.registers\[19\]\[29\] _1705_ _1708_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__mux4_1
X_8931_ clknet_leaf_89_CLK _0091_ VGND VGND VPWR VPWR regfile.registers\[3\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
Xinput2 A1[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_8862_ clknet_leaf_71_CLK _0022_ VGND VGND VPWR VPWR regfile.registers\[4\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_8793_ clknet_leaf_38_CLK _0977_ VGND VGND VPWR VPWR regfile.registers\[14\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_7813_ net155 _3538_ _3866_ VGND VGND VPWR VPWR _3869_ sky130_fd_sc_hd__mux2_1
X_7744_ _3832_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_65_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4956_ _1711_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_116_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7675_ net311 _3536_ _3794_ VGND VGND VPWR VPWR _3796_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4887_ regfile.registers\[20\]\[0\] regfile.registers\[21\]\[0\] regfile.registers\[22\]\[0\]
+ regfile.registers\[23\]\[0\] _1641_ _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__mux4_1
X_6626_ _3222_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_37_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_37_CLK sky130_fd_sc_hd__clkbuf_8
X_9414_ clknet_leaf_55_CLK _0574_ VGND VGND VPWR VPWR regfile.registers\[1\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6557_ _3184_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__clkbuf_1
X_9345_ clknet_leaf_84_CLK _0505_ VGND VGND VPWR VPWR regfile.registers\[20\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_5508_ regfile.registers\[12\]\[6\] regfile.registers\[13\]\[6\] regfile.registers\[14\]\[6\]
+ regfile.registers\[15\]\[6\] _2113_ _2114_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9276_ clknet_leaf_46_CLK _0436_ VGND VGND VPWR VPWR regfile.registers\[18\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6488_ _3147_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__clkbuf_1
X_8227_ _4088_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5439_ regfile.registers\[24\]\[10\] regfile.registers\[25\]\[10\] regfile.registers\[26\]\[10\]
+ regfile.registers\[27\]\[10\] _1674_ _1691_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__mux4_1
X_8158_ net744 _3542_ _4047_ VGND VGND VPWR VPWR _4052_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7109_ net35 VGND VGND VPWR VPWR _3480_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8089_ _4015_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_28_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_28_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_108_666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4810_ _1564_ _1565_ _1048_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__mux2_1
X_5790_ _2271_ _2538_ VGND VGND VPWR VPWR _2540_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_1_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_38_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4741_ regfile.registers\[16\]\[15\] regfile.registers\[17\]\[15\] regfile.registers\[18\]\[15\]
+ regfile.registers\[19\]\[15\] _1262_ _1263_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__mux4_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4672_ _1426_ _1427_ _1211_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_19_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_19_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7460_ _3056_ net826 _3675_ VGND VGND VPWR VPWR _3682_ sky130_fd_sc_hd__mux2_1
XFILLER_0_114_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6411_ net479 _3095_ _3093_ VGND VGND VPWR VPWR _3096_ sky130_fd_sc_hd__mux2_1
XFILLER_0_114_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9130_ clknet_leaf_104_CLK _0290_ VGND VGND VPWR VPWR regfile.registers\[28\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_7391_ _3056_ net516 _3638_ VGND VGND VPWR VPWR _3645_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_116_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6342_ net19 VGND VGND VPWR VPWR _3048_ sky130_fd_sc_hd__buf_2
X_6273_ _2958_ _2997_ _2363_ VGND VGND VPWR VPWR _2998_ sky130_fd_sc_hd__mux2_1
X_9061_ clknet_leaf_65_CLK _0221_ VGND VGND VPWR VPWR regfile.registers\[26\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_5224_ _1800_ _1979_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__nor2_1
X_8012_ _3951_ VGND VGND VPWR VPWR _3974_ sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_47_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5155_ _1909_ _1910_ _1745_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5086_ _1638_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__clkbuf_4
X_8914_ clknet_leaf_48_CLK _0074_ VGND VGND VPWR VPWR regfile.registers\[19\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_127_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8845_ clknet_leaf_93_CLK _0005_ VGND VGND VPWR VPWR regfile.registers\[5\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_56_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5988_ _2725_ _2728_ VGND VGND VPWR VPWR _2729_ sky130_fd_sc_hd__xnor2_1
X_8776_ clknet_leaf_100_CLK _0960_ VGND VGND VPWR VPWR regfile.registers\[14\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_4939_ _1688_ _1694_ _1686_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__mux2_1
X_7727_ _3823_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7658_ net1083 _3519_ _3783_ VGND VGND VPWR VPWR _3787_ sky130_fd_sc_hd__mux2_1
XFILLER_0_117_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6609_ _3213_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7589_ _3750_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9328_ clknet_leaf_9_CLK _0488_ VGND VGND VPWR VPWR regfile.registers\[21\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_65_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9259_ clknet_leaf_105_CLK _0419_ VGND VGND VPWR VPWR regfile.registers\[18\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_8_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_8_CLK sky130_fd_sc_hd__clkbuf_8
X_6960_ _3400_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_5911_ _2654_ _2655_ VGND VGND VPWR VPWR _2656_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6891_ net380 _3137_ _3362_ VGND VGND VPWR VPWR _3364_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8630_ clknet_leaf_53_CLK _0814_ VGND VGND VPWR VPWR regfile.registers\[17\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_124_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5842_ _1666_ _2040_ VGND VGND VPWR VPWR _2590_ sky130_fd_sc_hd__or2_1
XFILLER_0_76_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8561_ _4264_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__clkbuf_1
X_5773_ _2338_ _2365_ VGND VGND VPWR VPWR _2524_ sky130_fd_sc_hd__nor2_1
X_7512_ _3709_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4724_ _1215_ _1471_ _1475_ _1479_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__a2bb2o_2
X_8492_ net664 net29 _4227_ VGND VGND VPWR VPWR _4229_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7443_ _3039_ net404 _3664_ VGND VGND VPWR VPWR _3673_ sky130_fd_sc_hd__mux2_1
X_4655_ regfile.registers\[4\]\[7\] regfile.registers\[5\]\[7\] regfile.registers\[6\]\[7\]
+ regfile.registers\[7\]\[7\] _1290_ _1193_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__mux4_1
XFILLER_0_102_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4586_ regfile.registers\[8\]\[30\] regfile.registers\[9\]\[30\] regfile.registers\[10\]\[30\]
+ regfile.registers\[11\]\[30\] _1182_ _1184_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__mux4_1
Xhold800 regfile.registers\[24\]\[9\] VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dlygate4sd3_1
X_7374_ _3039_ net509 _3627_ VGND VGND VPWR VPWR _3636_ sky130_fd_sc_hd__mux2_1
Xhold811 regfile.registers\[17\]\[5\] VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold833 regfile.registers\[14\]\[21\] VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlygate4sd3_1
X_9113_ clknet_leaf_39_CLK _0273_ VGND VGND VPWR VPWR regfile.registers\[27\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold822 regfile.registers\[20\]\[9\] VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__dlygate4sd3_1
Xhold844 regfile.registers\[14\]\[13\] VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlygate4sd3_1
X_6325_ _3036_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__clkbuf_1
Xhold855 regfile.registers\[24\]\[7\] VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__dlygate4sd3_1
Xhold888 regfile.registers\[14\]\[24\] VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__dlygate4sd3_1
X_9044_ clknet_leaf_22_CLK _0204_ VGND VGND VPWR VPWR regfile.registers\[31\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold877 regfile.registers\[30\]\[13\] VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlygate4sd3_1
Xhold866 regfile.registers\[14\]\[11\] VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__dlygate4sd3_1
X_6256_ _2741_ _2981_ VGND VGND VPWR VPWR _2982_ sky130_fd_sc_hd__nor2_1
Xhold899 regfile.registers\[23\]\[22\] VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6187_ _1978_ _2915_ VGND VGND VPWR VPWR _2916_ sky130_fd_sc_hd__or2_1
X_5207_ regfile.registers\[20\]\[27\] regfile.registers\[21\]\[27\] regfile.registers\[22\]\[27\]
+ regfile.registers\[23\]\[27\] _1767_ _1768_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__mux4_1
X_5138_ _1773_ _1893_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5069_ regfile.registers\[28\]\[19\] regfile.registers\[29\]\[19\] regfile.registers\[30\]\[19\]
+ regfile.registers\[31\]\[19\] _1676_ _1681_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__mux4_1
X_8828_ clknet_leaf_43_CLK _1012_ VGND VGND VPWR VPWR regfile.registers\[6\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_8759_ clknet_leaf_37_CLK _0943_ VGND VGND VPWR VPWR regfile.registers\[8\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_73_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_91_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold107 regfile.registers\[17\]\[27\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
X_4440_ regfile.registers\[12\]\[29\] regfile.registers\[13\]\[29\] regfile.registers\[14\]\[29\]
+ regfile.registers\[15\]\[29\] _1192_ _1195_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__mux4_1
XFILLER_0_41_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold118 regfile.registers\[6\]\[8\] VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold129 regfile.registers\[17\]\[13\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
X_4371_ _1111_ _1126_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__and2_2
X_6110_ _2827_ _2831_ _2843_ VGND VGND VPWR VPWR _2844_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_59_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7090_ _3469_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
X_6041_ _2704_ _2778_ _1879_ VGND VGND VPWR VPWR _2779_ sky130_fd_sc_hd__mux2_1
X_7992_ _3113_ net707 _3963_ VGND VGND VPWR VPWR _3964_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6943_ _3391_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6874_ net513 _3120_ _3351_ VGND VGND VPWR VPWR _3355_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5825_ _2255_ _2461_ _2463_ _2337_ VGND VGND VPWR VPWR _2574_ sky130_fd_sc_hd__o22a_1
X_8613_ clknet_leaf_63_CLK _0797_ VGND VGND VPWR VPWR regfile.registers\[17\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5756_ _1060_ _2507_ VGND VGND VPWR VPWR _2508_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8544_ net278 net21 _4255_ VGND VGND VPWR VPWR _4256_ sky130_fd_sc_hd__mux2_1
X_5687_ _2252_ _2437_ _2440_ VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8475_ net766 net20 _4216_ VGND VGND VPWR VPWR _4220_ sky130_fd_sc_hd__mux2_1
X_4707_ _1457_ _1459_ _1462_ _1071_ _1057_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__a221o_1
XFILLER_0_115_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7426_ _3663_ VGND VGND VPWR VPWR _3664_ sky130_fd_sc_hd__clkbuf_8
X_4638_ _1036_ _1393_ _1037_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__o21a_1
XFILLER_0_102_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold630 regfile.registers\[20\]\[1\] VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlygate4sd3_1
Xhold663 regfile.registers\[20\]\[22\] VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlygate4sd3_1
Xhold641 regfile.registers\[18\]\[26\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlygate4sd3_1
X_7357_ _3626_ VGND VGND VPWR VPWR _3627_ sky130_fd_sc_hd__clkbuf_8
Xhold652 regfile.registers\[15\]\[11\] VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dlygate4sd3_1
X_4569_ _1029_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__buf_4
Xhold696 regfile.registers\[27\]\[31\] VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlygate4sd3_1
Xhold685 regfile.registers\[4\]\[8\] VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlygate4sd3_1
X_7288_ _3588_ _3589_ VGND VGND VPWR VPWR _3590_ sky130_fd_sc_hd__nand2_4
Xhold674 regfile.registers\[22\]\[12\] VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dlygate4sd3_1
X_6308_ net27 VGND VGND VPWR VPWR _3025_ sky130_fd_sc_hd__clkbuf_2
X_6239_ _2965_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_6
X_9027_ clknet_leaf_84_CLK _0187_ VGND VGND VPWR VPWR regfile.registers\[31\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_86_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone41 net95 VGND VGND VPWR VPWR net1150 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_97_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5610_ _1169_ _2098_ _1803_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__a21bo_1
X_6590_ _3203_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5541_ regfile.registers\[12\]\[4\] regfile.registers\[13\]\[4\] regfile.registers\[14\]\[4\]
+ regfile.registers\[15\]\[4\] _1718_ _1721_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__mux4_1
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8260_ _3109_ net359 _4097_ VGND VGND VPWR VPWR _4106_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7211_ _3548_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
X_5472_ _1717_ _2227_ _1729_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__a21oi_1
X_4423_ _1176_ _1177_ _1178_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__mux2_1
X_8191_ _4069_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7142_ net151 _3502_ _3492_ VGND VGND VPWR VPWR _3503_ sky130_fd_sc_hd__mux2_1
X_4354_ _1057_ _1094_ _1098_ _1102_ _1109_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__a32o_2
XTAP_TAPCELL_ROW_70_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7073_ net610 _3113_ _3460_ VGND VGND VPWR VPWR _3461_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6024_ _1858_ _2762_ VGND VGND VPWR VPWR _2763_ sky130_fd_sc_hd__xor2_1
X_4285_ A2[0] VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__buf_12
XFILLER_0_39_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7975_ _3097_ net1101 _3952_ VGND VGND VPWR VPWR _3955_ sky130_fd_sc_hd__mux2_1
X_6926_ _3382_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6857_ net331 _3103_ _3340_ VGND VGND VPWR VPWR _3346_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5808_ _1399_ net1142 _2535_ _2411_ VGND VGND VPWR VPWR _2557_ sky130_fd_sc_hd__a31o_1
X_6788_ _3033_ net567 _3303_ VGND VGND VPWR VPWR _3309_ sky130_fd_sc_hd__mux2_1
X_9576_ clknet_leaf_88_CLK _0736_ VGND VGND VPWR VPWR regfile.registers\[10\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_5739_ _2490_ _2179_ _2426_ VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__mux2_1
X_8527_ net445 net44 _4244_ VGND VGND VPWR VPWR _4247_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8458_ net132 net43 _4205_ VGND VGND VPWR VPWR _4211_ sky130_fd_sc_hd__mux2_1
X_7409_ _3654_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
X_8389_ _4174_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__clkbuf_1
Xhold460 regfile.registers\[22\]\[27\] VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__dlygate4sd3_1
Xhold471 regfile.registers\[12\]\[27\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__dlygate4sd3_1
Xhold482 regfile.registers\[24\]\[20\] VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlygate4sd3_1
Xhold493 regfile.registers\[6\]\[9\] VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload16 clknet_leaf_20_CLK VGND VGND VPWR VPWR clkload16/Y sky130_fd_sc_hd__clkinv_4
Xclkload49 clknet_leaf_34_CLK VGND VGND VPWR VPWR clkload49/Y sky130_fd_sc_hd__clkinv_1
XFILLER_0_106_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload38 clknet_leaf_25_CLK VGND VGND VPWR VPWR clkload38/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_3_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload27 clknet_leaf_98_CLK VGND VGND VPWR VPWR clkload27/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_23_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7760_ _3840_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__clkbuf_1
X_4972_ net5 VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__buf_4
X_7691_ net290 _3484_ _3794_ VGND VGND VPWR VPWR _3804_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6711_ _3268_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_128_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9430_ clknet_leaf_53_CLK _0590_ VGND VGND VPWR VPWR regfile.registers\[1\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6642_ _3019_ net1050 _3231_ VGND VGND VPWR VPWR _3232_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9361_ clknet_leaf_18_CLK _0521_ VGND VGND VPWR VPWR regfile.registers\[20\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8312_ net113 _3490_ _4133_ VGND VGND VPWR VPWR _4134_ sky130_fd_sc_hd__mux2_1
X_6573_ net585 _3089_ _3194_ VGND VGND VPWR VPWR _3195_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_119_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9292_ clknet_leaf_107_CLK _0452_ VGND VGND VPWR VPWR regfile.registers\[25\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_5524_ _2278_ _2279_ _1685_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5455_ _1639_ _2210_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__or2_1
X_8243_ _4096_ VGND VGND VPWR VPWR _4097_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_14_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8174_ _3091_ _3190_ VGND VGND VPWR VPWR _4060_ sky130_fd_sc_hd__nor2_2
XFILLER_0_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4406_ regfile.registers\[4\]\[0\] regfile.registers\[5\]\[0\] regfile.registers\[6\]\[0\]
+ regfile.registers\[7\]\[0\] net87 _1061_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__mux4_1
X_5386_ _1669_ _2141_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__nor2_1
X_7125_ _3447_ _3190_ VGND VGND VPWR VPWR _3491_ sky130_fd_sc_hd__nor2_2
XFILLER_0_10_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4337_ _1091_ _1092_ _1040_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__mux2_2
X_7056_ net522 _3097_ _3449_ VGND VGND VPWR VPWR _3452_ sky130_fd_sc_hd__mux2_1
X_4268_ net8 VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__inv_2
X_6007_ _2123_ net106 _2726_ VGND VGND VPWR VPWR _2747_ sky130_fd_sc_hd__a21o_1
X_7958_ _3945_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7889_ net721 _3478_ _3902_ VGND VGND VPWR VPWR _3909_ sky130_fd_sc_hd__mux2_1
X_6909_ net563 _3015_ _3339_ VGND VGND VPWR VPWR _3373_ sky130_fd_sc_hd__mux2_1
XFILLER_0_119_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9559_ clknet_leaf_37_CLK _0719_ VGND VGND VPWR VPWR regfile.registers\[11\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_94_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold290 regfile.registers\[10\]\[0\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload105 clknet_leaf_69_CLK VGND VGND VPWR VPWR clkload105/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_24_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5240_ _1777_ _1987_ _1995_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_54_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5171_ regfile.registers\[20\]\[29\] regfile.registers\[21\]\[29\] regfile.registers\[22\]\[29\]
+ regfile.registers\[23\]\[29\] _1705_ _1708_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8930_ clknet_leaf_88_CLK _0090_ VGND VGND VPWR VPWR regfile.registers\[3\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
Xinput3 A1[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_4
XFILLER_0_36_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8861_ clknet_leaf_45_CLK _0021_ VGND VGND VPWR VPWR regfile.registers\[5\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_7812_ _3868_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__clkbuf_1
X_8792_ clknet_leaf_17_CLK _0976_ VGND VGND VPWR VPWR regfile.registers\[14\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_7743_ _3067_ net1000 _3830_ VGND VGND VPWR VPWR _3832_ sky130_fd_sc_hd__mux2_1
X_4955_ net3 VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7674_ _3795_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
X_4886_ net2 VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__clkbuf_4
X_6625_ net405 _3145_ _3216_ VGND VGND VPWR VPWR _3222_ sky130_fd_sc_hd__mux2_1
X_9413_ clknet_leaf_62_CLK _0573_ VGND VGND VPWR VPWR regfile.registers\[1\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_6556_ _3077_ net995 _3177_ VGND VGND VPWR VPWR _3184_ sky130_fd_sc_hd__mux2_1
X_9344_ clknet_leaf_77_CLK _0504_ VGND VGND VPWR VPWR regfile.registers\[20\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_9275_ clknet_leaf_27_CLK _0435_ VGND VGND VPWR VPWR regfile.registers\[18\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5507_ regfile.registers\[8\]\[6\] regfile.registers\[9\]\[6\] regfile.registers\[10\]\[6\]
+ regfile.registers\[11\]\[6\] _2113_ _2114_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8226_ net133 _3542_ _4083_ VGND VGND VPWR VPWR _4088_ sky130_fd_sc_hd__mux2_1
X_6487_ net508 _3002_ _3135_ VGND VGND VPWR VPWR _3147_ sky130_fd_sc_hd__mux2_1
X_5438_ _2144_ _2193_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8157_ _4051_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5369_ regfile.registers\[20\]\[14\] regfile.registers\[21\]\[14\] regfile.registers\[22\]\[14\]
+ regfile.registers\[23\]\[14\] _1733_ _1679_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__mux4_1
X_8088_ net177 _3540_ _4011_ VGND VGND VPWR VPWR _4015_ sky130_fd_sc_hd__mux2_1
X_7108_ _3479_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
X_7039_ net339 _3009_ _3434_ VGND VGND VPWR VPWR _3442_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_123_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4740_ regfile.registers\[20\]\[15\] regfile.registers\[21\]\[15\] regfile.registers\[22\]\[15\]
+ regfile.registers\[23\]\[15\] _1262_ _1263_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4671_ regfile.registers\[0\]\[23\] regfile.registers\[1\]\[23\] regfile.registers\[2\]\[23\]
+ regfile.registers\[3\]\[23\] _1192_ _1195_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6410_ net27 VGND VGND VPWR VPWR _3095_ sky130_fd_sc_hd__buf_2
X_7390_ _3644_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6341_ _3047_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6272_ _2379_ _2377_ VGND VGND VPWR VPWR _2997_ sky130_fd_sc_hd__or2_1
X_9060_ clknet_leaf_92_CLK _0220_ VGND VGND VPWR VPWR regfile.registers\[26\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_5223_ _1842_ _1978_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_102_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8011_ _3973_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5154_ regfile.registers\[24\]\[30\] regfile.registers\[25\]\[30\] regfile.registers\[26\]\[30\]
+ regfile.registers\[27\]\[30\] _1895_ _1897_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__mux4_1
X_5085_ _1669_ _1821_ _1840_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8913_ clknet_leaf_5_CLK _0073_ VGND VGND VPWR VPWR regfile.registers\[19\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8844_ clknet_leaf_0_CLK _0004_ VGND VGND VPWR VPWR regfile.registers\[5\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_111_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5987_ _2726_ _2727_ VGND VGND VPWR VPWR _2728_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8775_ clknet_leaf_62_CLK _0959_ VGND VGND VPWR VPWR regfile.registers\[14\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_4938_ regfile.registers\[24\]\[23\] regfile.registers\[25\]\[23\] regfile.registers\[26\]\[23\]
+ regfile.registers\[27\]\[23\] _1689_ _1693_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__mux4_1
X_7726_ _3050_ net957 _3819_ VGND VGND VPWR VPWR _3823_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7657_ _3786_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__clkbuf_1
X_4869_ _1621_ _1624_ _1213_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__mux2_1
XFILLER_0_105_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6608_ net677 _3128_ _3205_ VGND VGND VPWR VPWR _3213_ sky130_fd_sc_hd__mux2_1
XFILLER_0_105_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7588_ _3048_ net1042 _3747_ VGND VGND VPWR VPWR _3750_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9327_ clknet_leaf_2_CLK _0487_ VGND VGND VPWR VPWR regfile.registers\[21\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_6539_ _3060_ net877 _3166_ VGND VGND VPWR VPWR _3175_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_120_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9258_ clknet_leaf_107_CLK _0418_ VGND VGND VPWR VPWR regfile.registers\[18\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_9189_ clknet_leaf_66_CLK _0349_ VGND VGND VPWR VPWR regfile.registers\[30\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_8209_ net145 _3525_ _4072_ VGND VGND VPWR VPWR _4079_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5910_ _2471_ _2605_ _2591_ _2462_ VGND VGND VPWR VPWR _2655_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6890_ _3363_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_124_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5841_ _1880_ _2588_ _2421_ VGND VGND VPWR VPWR _2589_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_62_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5772_ _1111_ _2522_ _2487_ _2382_ VGND VGND VPWR VPWR _2523_ sky130_fd_sc_hd__o2bb2a_1
X_8560_ net1135 net30 _4255_ VGND VGND VPWR VPWR _4264_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8491_ _4228_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__clkbuf_1
X_7511_ _3039_ net960 _3700_ VGND VGND VPWR VPWR _3709_ sky130_fd_sc_hd__mux2_1
X_4723_ _1205_ _1478_ _1170_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__a21oi_1
X_7442_ _3672_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
X_4654_ _1071_ _1409_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__nand2_1
X_4585_ _1189_ _1340_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__and2_1
Xhold801 regfile.registers\[0\]\[31\] VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dlygate4sd3_1
X_7373_ _3635_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold812 regfile.registers\[3\]\[10\] VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__dlygate4sd3_1
Xhold834 regfile.registers\[27\]\[26\] VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__dlygate4sd3_1
X_9112_ clknet_leaf_21_CLK _0272_ VGND VGND VPWR VPWR regfile.registers\[27\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold823 regfile.registers\[8\]\[12\] VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__dlygate4sd3_1
X_6324_ _3035_ net1111 _3023_ VGND VGND VPWR VPWR _3036_ sky130_fd_sc_hd__mux2_1
Xhold845 regfile.registers\[13\]\[0\] VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__dlygate4sd3_1
Xhold856 regfile.registers\[17\]\[21\] VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__dlygate4sd3_1
X_9043_ clknet_leaf_27_CLK _0203_ VGND VGND VPWR VPWR regfile.registers\[31\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold878 regfile.registers\[27\]\[21\] VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__dlygate4sd3_1
X_6255_ _1238_ _2929_ VGND VGND VPWR VPWR _2981_ sky130_fd_sc_hd__nor2_1
Xhold867 regfile.registers\[23\]\[17\] VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlygate4sd3_1
Xhold889 regfile.registers\[2\]\[6\] VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__dlygate4sd3_1
X_5206_ _1926_ _1961_ _1877_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_73_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6186_ _1315_ _2914_ VGND VGND VPWR VPWR _2915_ sky130_fd_sc_hd__xor2_1
X_5137_ _1891_ _1892_ _1889_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5068_ regfile.registers\[24\]\[19\] regfile.registers\[25\]\[19\] regfile.registers\[26\]\[19\]
+ regfile.registers\[27\]\[19\] _1822_ _1823_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__mux4_1
X_8827_ clknet_leaf_42_CLK _1011_ VGND VGND VPWR VPWR regfile.registers\[6\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8758_ clknet_leaf_48_CLK _0942_ VGND VGND VPWR VPWR regfile.registers\[8\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7709_ _3033_ net939 _3808_ VGND VGND VPWR VPWR _3814_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8689_ clknet_leaf_14_CLK _0873_ VGND VGND VPWR VPWR regfile.registers\[0\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_640 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold108 regfile.registers\[18\]\[9\] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4370_ net84 VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__clkbuf_4
Xhold119 regfile.registers\[10\]\[4\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_123_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6040_ _2734_ _2777_ _1877_ VGND VGND VPWR VPWR _2778_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7991_ _3951_ VGND VGND VPWR VPWR _3963_ sky130_fd_sc_hd__buf_6
XFILLER_0_89_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6942_ net251 _3120_ _3387_ VGND VGND VPWR VPWR _3391_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_124_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6873_ _3354_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5824_ _2470_ _2460_ _2252_ VGND VGND VPWR VPWR _2573_ sky130_fd_sc_hd__mux2_1
X_8612_ clknet_leaf_93_CLK _0796_ VGND VGND VPWR VPWR regfile.registers\[17\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5755_ _2411_ net89 VGND VGND VPWR VPWR _2507_ sky130_fd_sc_hd__nor2_1
X_8543_ _3006_ VGND VGND VPWR VPWR _4255_ sky130_fd_sc_hd__buf_6
XFILLER_0_17_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5686_ _2252_ _2439_ VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8474_ _4219_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__clkbuf_1
X_4706_ _1460_ _1461_ _1048_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7425_ _3153_ _3662_ VGND VGND VPWR VPWR _3663_ sky130_fd_sc_hd__nand2_4
X_4637_ regfile.registers\[12\]\[6\] regfile.registers\[13\]\[6\] regfile.registers\[14\]\[6\]
+ regfile.registers\[15\]\[6\] _1290_ _1193_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold620 regfile.registers\[23\]\[1\] VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold631 regfile.registers\[23\]\[24\] VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dlygate4sd3_1
X_7356_ _3021_ _3589_ VGND VGND VPWR VPWR _3626_ sky130_fd_sc_hd__nand2_4
Xhold642 regfile.registers\[31\]\[19\] VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlygate4sd3_1
Xhold653 regfile.registers\[24\]\[4\] VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dlygate4sd3_1
X_4568_ _1027_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__buf_8
Xhold664 regfile.registers\[24\]\[24\] VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlygate4sd3_1
X_4499_ _1248_ _1250_ _1253_ _1254_ _1170_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__a221o_1
X_7287_ net13 net12 net11 VGND VGND VPWR VPWR _3589_ sky130_fd_sc_hd__and3_4
Xhold686 regfile.registers\[11\]\[13\] VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlygate4sd3_1
Xhold675 regfile.registers\[11\]\[6\] VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlygate4sd3_1
Xhold697 regfile.registers\[24\]\[0\] VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlygate4sd3_1
X_6307_ _3024_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__clkbuf_1
X_6238_ _2964_ _2963_ _2957_ VGND VGND VPWR VPWR _2965_ sky130_fd_sc_hd__or3_4
X_9026_ clknet_leaf_86_CLK _0186_ VGND VGND VPWR VPWR regfile.registers\[31\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_6169_ _2613_ _2737_ _2898_ _2899_ VGND VGND VPWR VPWR _2900_ sky130_fd_sc_hd__a211o_1
XFILLER_0_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclone20 A2[0] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_106_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_128_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5540_ _2292_ _2295_ _1696_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5471_ _2225_ _2226_ _1739_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7210_ net300 _3482_ _3534_ VGND VGND VPWR VPWR _3548_ sky130_fd_sc_hd__mux2_1
X_4422_ _1036_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__buf_4
XFILLER_0_112_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8190_ net674 _3506_ _4061_ VGND VGND VPWR VPWR _4069_ sky130_fd_sc_hd__mux2_1
X_7141_ net43 VGND VGND VPWR VPWR _3502_ sky130_fd_sc_hd__buf_2
X_4353_ _1108_ _1088_ net8 VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_70_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7072_ _3448_ VGND VGND VPWR VPWR _3460_ sky130_fd_sc_hd__clkbuf_8
X_4284_ _1034_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__buf_4
X_6023_ _1601_ _2761_ VGND VGND VPWR VPWR _2762_ sky130_fd_sc_hd__xor2_1
X_7974_ _3954_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6925_ net355 _3103_ _3376_ VGND VGND VPWR VPWR _3382_ sky130_fd_sc_hd__mux2_1
X_6856_ _3345_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__clkbuf_1
X_5807_ _2504_ _2544_ _2545_ _2556_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_81_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9575_ clknet_leaf_59_CLK _0735_ VGND VGND VPWR VPWR regfile.registers\[10\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_6787_ _3308_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5738_ _1878_ VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__inv_2
X_8526_ _4246_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_115_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5669_ _1876_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__inv_2
X_8457_ _4210_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__clkbuf_1
X_7408_ _3073_ net1010 _3649_ VGND VGND VPWR VPWR _3654_ sky130_fd_sc_hd__mux2_1
X_8388_ net415 _3500_ _4169_ VGND VGND VPWR VPWR _4174_ sky130_fd_sc_hd__mux2_1
X_7339_ _3617_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
Xhold461 regfile.registers\[26\]\[27\] VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__dlygate4sd3_1
Xhold450 regfile.registers\[0\]\[29\] VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__dlygate4sd3_1
Xhold472 regfile.registers\[21\]\[15\] VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlygate4sd3_1
Xhold483 regfile.registers\[6\]\[30\] VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlygate4sd3_1
Xhold494 regfile.registers\[0\]\[11\] VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__dlygate4sd3_1
X_9009_ clknet_leaf_4_CLK _0169_ VGND VGND VPWR VPWR regfile.registers\[29\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload17 clknet_leaf_107_CLK VGND VGND VPWR VPWR clkload17/Y sky130_fd_sc_hd__clkinvlp_2
XTAP_TAPCELL_ROW_11_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload39 clknet_leaf_26_CLK VGND VGND VPWR VPWR clkload39/Y sky130_fd_sc_hd__clkinv_4
Xclkload28 clknet_leaf_99_CLK VGND VGND VPWR VPWR clkload28/Y sky130_fd_sc_hd__clkinvlp_4
XTAP_TAPCELL_ROW_56_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4971_ _1724_ _1725_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7690_ _3803_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6710_ net992 _3089_ _3267_ VGND VGND VPWR VPWR _3268_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6641_ _3230_ VGND VGND VPWR VPWR _3231_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_116_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9360_ clknet_leaf_97_CLK _0520_ VGND VGND VPWR VPWR regfile.registers\[20\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_6572_ _3193_ VGND VGND VPWR VPWR _3194_ sky130_fd_sc_hd__clkbuf_8
X_8311_ _4132_ VGND VGND VPWR VPWR _4133_ sky130_fd_sc_hd__clkbuf_8
X_9291_ clknet_leaf_104_CLK _0451_ VGND VGND VPWR VPWR regfile.registers\[25\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5523_ regfile.registers\[8\]\[7\] regfile.registers\[9\]\[7\] regfile.registers\[10\]\[7\]
+ regfile.registers\[11\]\[7\] _2113_ _2114_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_119_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8242_ _3588_ _3229_ VGND VGND VPWR VPWR _4096_ sky130_fd_sc_hd__nand2_4
X_5454_ _1670_ _2201_ _2205_ _2209_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_100_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5385_ _1639_ _2140_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__nor2_1
X_8173_ _4059_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4405_ _1038_ _1160_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4336_ regfile.registers\[16\]\[3\] regfile.registers\[17\]\[3\] regfile.registers\[18\]\[3\]
+ regfile.registers\[19\]\[3\] _1089_ _1090_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__mux4_1
X_7124_ net16 VGND VGND VPWR VPWR _3490_ sky130_fd_sc_hd__buf_2
X_7055_ _3451_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_6006_ _2712_ _2713_ _2725_ VGND VGND VPWR VPWR _2746_ sky130_fd_sc_hd__or3_1
XFILLER_0_96_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7957_ _3002_ net211 _3938_ VGND VGND VPWR VPWR _3945_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7888_ _3908_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__clkbuf_1
X_6908_ _3372_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__clkbuf_1
X_6839_ _3335_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9558_ clknet_leaf_49_CLK _0718_ VGND VGND VPWR VPWR regfile.registers\[11\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8509_ _4237_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__clkbuf_1
X_9489_ clknet_leaf_5_CLK _0649_ VGND VGND VPWR VPWR regfile.registers\[16\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold280 regfile.registers\[3\]\[18\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold291 regfile.registers\[2\]\[9\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload106 clknet_leaf_70_CLK VGND VGND VPWR VPWR clkload106/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5170_ _1169_ _1905_ _1925_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__o21ai_1
Xinput4 A1[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_4
X_8860_ clknet_leaf_44_CLK _0020_ VGND VGND VPWR VPWR regfile.registers\[5\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_8791_ clknet_leaf_36_CLK _0975_ VGND VGND VPWR VPWR regfile.registers\[14\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_7811_ net437 _3536_ _3866_ VGND VGND VPWR VPWR _3868_ sky130_fd_sc_hd__mux2_1
X_4954_ regfile.registers\[12\]\[23\] regfile.registers\[13\]\[23\] regfile.registers\[14\]\[23\]
+ regfile.registers\[15\]\[23\] _1705_ _1708_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__mux4_1
X_7742_ _3831_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_129_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7673_ net128 _3533_ _3794_ VGND VGND VPWR VPWR _3795_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4885_ net1 VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__buf_4
X_9412_ clknet_leaf_64_CLK _0572_ VGND VGND VPWR VPWR regfile.registers\[1\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_6624_ _3221_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6555_ _3183_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9343_ clknet_leaf_79_CLK _0503_ VGND VGND VPWR VPWR regfile.registers\[20\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9274_ clknet_leaf_25_CLK _0434_ VGND VGND VPWR VPWR regfile.registers\[18\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5506_ _2258_ _2261_ _1696_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__mux2_1
X_6486_ _3146_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__clkbuf_1
X_8225_ _4087_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5437_ _1670_ _2184_ _2188_ _2192_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__o22a_4
X_8156_ net594 _3540_ _4047_ VGND VGND VPWR VPWR _4051_ sky130_fd_sc_hd__mux2_1
X_5368_ _1639_ _2123_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__nor2_1
X_8087_ _4014_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__clkbuf_1
X_7107_ net285 _3478_ _3471_ VGND VGND VPWR VPWR _3479_ sky130_fd_sc_hd__mux2_1
X_4319_ regfile.registers\[12\]\[5\] regfile.registers\[13\]\[5\] regfile.registers\[14\]\[5\]
+ regfile.registers\[15\]\[5\] net97 _1073_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__mux4_1
X_5299_ regfile.registers\[12\]\[3\] regfile.registers\[13\]\[3\] regfile.registers\[14\]\[3\]
+ regfile.registers\[15\]\[3\] _2051_ _2053_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__mux4_1
X_7038_ _3441_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_8989_ clknet_leaf_43_CLK _0149_ VGND VGND VPWR VPWR regfile.registers\[7\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_105_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_105_CLK
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_49_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4670_ regfile.registers\[4\]\[23\] regfile.registers\[5\]\[23\] regfile.registers\[6\]\[23\]
+ regfile.registers\[7\]\[23\] _1192_ _1195_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6340_ _3046_ net1067 _3044_ VGND VGND VPWR VPWR _3047_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_116_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6271_ _2942_ VGND VGND VPWR VPWR _2996_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5222_ _1777_ _1969_ _1973_ _1977_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__o2bb2a_1
X_8010_ _3132_ net931 _3963_ VGND VGND VPWR VPWR _3973_ sky130_fd_sc_hd__mux2_1
X_5153_ regfile.registers\[28\]\[30\] regfile.registers\[29\]\[30\] regfile.registers\[30\]\[30\]
+ regfile.registers\[31\]\[30\] _1895_ _1897_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_75_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5084_ _1758_ _1838_ _1839_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__o21a_1
X_8912_ clknet_leaf_11_CLK _0072_ VGND VGND VPWR VPWR regfile.registers\[19\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8843_ clknet_leaf_98_CLK _0003_ VGND VGND VPWR VPWR regfile.registers\[5\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5986_ net93 _2714_ VGND VGND VPWR VPWR _2727_ sky130_fd_sc_hd__or2b_1
X_8774_ clknet_leaf_67_CLK _0958_ VGND VGND VPWR VPWR regfile.registers\[14\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4937_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__buf_4
X_7725_ _3822_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7656_ net292 _3517_ _3783_ VGND VGND VPWR VPWR _3786_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4868_ _1622_ _1623_ _1259_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__mux2_1
XFILLER_0_105_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6607_ _3212_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_105_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_6__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_6__leaf_CLK sky130_fd_sc_hd__clkbuf_16
X_9326_ clknet_leaf_4_CLK _0486_ VGND VGND VPWR VPWR regfile.registers\[21\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_7587_ _3749_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4799_ regfile.registers\[0\]\[10\] regfile.registers\[1\]\[10\] regfile.registers\[2\]\[10\]
+ regfile.registers\[3\]\[10\] _1104_ _1105_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__mux4_1
X_6538_ _3174_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6469_ _3092_ VGND VGND VPWR VPWR _3135_ sky130_fd_sc_hd__buf_6
X_9257_ clknet_leaf_99_CLK _0417_ VGND VGND VPWR VPWR regfile.registers\[18\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_112_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9188_ clknet_leaf_92_CLK _0348_ VGND VGND VPWR VPWR regfile.registers\[30\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_8208_ _4078_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__clkbuf_1
X_8139_ net945 _3523_ _4036_ VGND VGND VPWR VPWR _4042_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5840_ _2040_ _2372_ VGND VGND VPWR VPWR _2588_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5771_ _2388_ _2397_ _1126_ VGND VGND VPWR VPWR _2522_ sky130_fd_sc_hd__mux2_1
XFILLER_0_127_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8490_ net329 net28 _4227_ VGND VGND VPWR VPWR _4228_ sky130_fd_sc_hd__mux2_1
X_4722_ _1476_ _1477_ _1198_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__mux2_1
X_7510_ _3708_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7441_ _3037_ net1026 _3664_ VGND VGND VPWR VPWR _3672_ sky130_fd_sc_hd__mux2_1
XFILLER_0_126_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput40 WD3[31] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
X_4653_ _1407_ _1408_ _1040_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__mux2_1
X_4584_ regfile.registers\[12\]\[30\] regfile.registers\[13\]\[30\] regfile.registers\[14\]\[30\]
+ regfile.registers\[15\]\[30\] net1150 _1222_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__mux4_1
X_7372_ _3037_ net929 _3627_ VGND VGND VPWR VPWR _3635_ sky130_fd_sc_hd__mux2_1
Xhold802 regfile.registers\[31\]\[15\] VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__dlygate4sd3_1
X_9111_ clknet_leaf_34_CLK _0271_ VGND VGND VPWR VPWR regfile.registers\[27\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold846 regfile.registers\[16\]\[28\] VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlygate4sd3_1
Xhold824 regfile.registers\[26\]\[29\] VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__dlygate4sd3_1
Xhold813 regfile.registers\[22\]\[19\] VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold835 regfile.registers\[30\]\[0\] VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__dlygate4sd3_1
X_6323_ net44 VGND VGND VPWR VPWR _3035_ sky130_fd_sc_hd__clkbuf_2
X_6254_ _2974_ _2797_ _2979_ _2421_ VGND VGND VPWR VPWR _2980_ sky130_fd_sc_hd__o211a_1
Xhold879 regfile.registers\[22\]\[28\] VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__dlygate4sd3_1
X_9042_ clknet_leaf_42_CLK _0202_ VGND VGND VPWR VPWR regfile.registers\[31\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold868 regfile.registers\[24\]\[26\] VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__dlygate4sd3_1
Xhold857 regfile.registers\[10\]\[11\] VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__dlygate4sd3_1
X_5205_ _1944_ _1960_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__or2_1
X_6185_ _1447_ _1299_ _2901_ _2871_ _2741_ VGND VGND VPWR VPWR _2914_ sky130_fd_sc_hd__a41o_1
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5136_ regfile.registers\[12\]\[31\] regfile.registers\[13\]\[31\] regfile.registers\[14\]\[31\]
+ regfile.registers\[15\]\[31\] _1882_ _1884_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_4_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5067_ _1735_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_88_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8826_ clknet_leaf_32_CLK _1010_ VGND VGND VPWR VPWR regfile.registers\[6\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8757_ clknet_leaf_31_CLK _0941_ VGND VGND VPWR VPWR regfile.registers\[8\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_5969_ _2710_ _1494_ VGND VGND VPWR VPWR _2711_ sky130_fd_sc_hd__xor2_2
X_7708_ _3813_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8688_ clknet_leaf_10_CLK _0872_ VGND VGND VPWR VPWR regfile.registers\[0\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7639_ net667 _3500_ _3772_ VGND VGND VPWR VPWR _3777_ sky130_fd_sc_hd__mux2_1
X_9309_ clknet_leaf_13_CLK _0469_ VGND VGND VPWR VPWR regfile.registers\[25\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold109 regfile.registers\[2\]\[22\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7990_ _3962_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_1
X_6941_ _3390_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_124_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6872_ net206 _3118_ _3351_ VGND VGND VPWR VPWR _3354_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9591_ clknet_leaf_37_CLK _0751_ VGND VGND VPWR VPWR regfile.registers\[10\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_5823_ _2472_ _2570_ _2571_ _1111_ VGND VGND VPWR VPWR _2572_ sky130_fd_sc_hd__a22o_1
X_8611_ clknet_leaf_81_CLK _0795_ VGND VGND VPWR VPWR regfile.registers\[17\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8542_ _4254_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5754_ _1125_ _1110_ _1144_ _1166_ VGND VGND VPWR VPWR _2506_ sky130_fd_sc_hd__and4_1
XFILLER_0_72_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_94_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_94_CLK sky130_fd_sc_hd__clkbuf_8
X_5685_ _2178_ _1802_ _2438_ VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_17_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8473_ net365 net19 _4216_ VGND VGND VPWR VPWR _4219_ sky130_fd_sc_hd__mux2_1
X_4705_ regfile.registers\[12\]\[12\] regfile.registers\[13\]\[12\] regfile.registers\[14\]\[12\]
+ regfile.registers\[15\]\[12\] _1181_ _1183_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__mux4_1
XFILLER_0_72_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7424_ net11 net12 net13 VGND VGND VPWR VPWR _3662_ sky130_fd_sc_hd__and3b_4
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4636_ _1048_ _1391_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7355_ _3625_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
Xhold610 regfile.registers\[19\]\[7\] VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold621 regfile.registers\[27\]\[3\] VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlygate4sd3_1
Xhold654 regfile.registers\[25\]\[27\] VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlygate4sd3_1
X_4567_ _1319_ _1322_ _1213_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__mux2_1
Xhold632 regfile.registers\[25\]\[1\] VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6306_ _3019_ net829 _3023_ VGND VGND VPWR VPWR _3024_ sky130_fd_sc_hd__mux2_1
Xhold643 regfile.registers\[25\]\[15\] VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlygate4sd3_1
X_4498_ _1205_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__buf_4
Xhold687 regfile.registers\[25\]\[24\] VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold676 regfile.registers\[4\]\[28\] VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlygate4sd3_1
X_7286_ net10 net9 net48 VGND VGND VPWR VPWR _3588_ sky130_fd_sc_hd__and3b_4
Xhold665 regfile.registers\[26\]\[5\] VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlygate4sd3_1
Xhold698 regfile.registers\[19\]\[21\] VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlygate4sd3_1
X_6237_ _2701_ _2797_ VGND VGND VPWR VPWR _2964_ sky130_fd_sc_hd__nor2_1
X_9025_ clknet_leaf_84_CLK _0185_ VGND VGND VPWR VPWR regfile.registers\[31\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_6168_ _2390_ _2864_ _2333_ VGND VGND VPWR VPWR _2899_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5119_ _1758_ _1874_ _1800_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__o21ai_1
X_6099_ _2806_ _2827_ _2831_ _2833_ VGND VGND VPWR VPWR _2834_ sky130_fd_sc_hd__o31a_1
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8809_ clknet_leaf_97_CLK _0993_ VGND VGND VPWR VPWR regfile.registers\[6\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_85_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_85_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_106_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclone21 _1027_ VGND VGND VPWR VPWR net1141 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_106_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_128_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_76_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_76_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_14_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5470_ regfile.registers\[0\]\[8\] regfile.registers\[1\]\[8\] regfile.registers\[2\]\[8\]
+ regfile.registers\[3\]\[8\] _1734_ _1735_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4421_ regfile.registers\[16\]\[29\] regfile.registers\[17\]\[29\] regfile.registers\[18\]\[29\]
+ regfile.registers\[19\]\[29\] _1173_ _1175_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__mux4_1
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7140_ _3501_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_4352_ _1103_ _1106_ _1107_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7071_ _3459_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_4283_ _1030_ _1031_ _1032_ _1033_ _1036_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__mux4_2
X_6022_ _1512_ _1587_ _2658_ _2741_ VGND VGND VPWR VPWR _2761_ sky130_fd_sc_hd__a31o_1
X_7973_ _3095_ net1004 _3952_ VGND VGND VPWR VPWR _3954_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6924_ _3381_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6855_ net243 _3101_ _3340_ VGND VGND VPWR VPWR _3345_ sky130_fd_sc_hd__mux2_1
XFILLER_0_119_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5806_ _2496_ _2549_ _2552_ _2555_ VGND VGND VPWR VPWR _2556_ sky130_fd_sc_hd__a211o_1
X_9574_ clknet_leaf_57_CLK _0734_ VGND VGND VPWR VPWR regfile.registers\[10\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_67_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_67_CLK sky130_fd_sc_hd__clkbuf_8
X_6786_ _3031_ net1129 _3303_ VGND VGND VPWR VPWR _3308_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5737_ _1666_ _2488_ VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__nor2_1
X_8525_ net283 net43 _4244_ VGND VGND VPWR VPWR _4246_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8456_ net204 net42 _4205_ VGND VGND VPWR VPWR _4210_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7407_ _3653_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_115_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5668_ _1128_ _2420_ _2421_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_17_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4619_ _1371_ _1372_ _1373_ _1374_ _1190_ _1254_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_96_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5599_ _2352_ _2353_ VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__and2_1
X_8387_ _4173_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__clkbuf_1
X_7338_ _3071_ net953 _3613_ VGND VGND VPWR VPWR _3617_ sky130_fd_sc_hd__mux2_1
Xhold462 regfile.registers\[28\]\[20\] VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__dlygate4sd3_1
Xhold451 regfile.registers\[6\]\[16\] VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlygate4sd3_1
Xhold440 regfile.registers\[2\]\[2\] VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__dlygate4sd3_1
X_7269_ _3579_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
Xhold473 regfile.registers\[28\]\[22\] VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__dlygate4sd3_1
Xhold484 regfile.registers\[28\]\[1\] VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlygate4sd3_1
Xhold495 regfile.registers\[7\]\[1\] VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__dlygate4sd3_1
X_9008_ clknet_leaf_8_CLK _0168_ VGND VGND VPWR VPWR regfile.registers\[29\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload29 clknet_leaf_103_CLK VGND VGND VPWR VPWR clkload29/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload18 clknet_leaf_108_CLK VGND VGND VPWR VPWR clkload18/Y sky130_fd_sc_hd__clkinv_8
XFILLER_0_35_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4970_ _1685_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_58_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_49_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_49_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_74_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6640_ _3021_ _3229_ VGND VGND VPWR VPWR _3230_ sky130_fd_sc_hd__nand2_4
XFILLER_0_58_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6571_ _3190_ _3192_ VGND VGND VPWR VPWR _3193_ sky130_fd_sc_hd__nor2_2
XFILLER_0_109_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8310_ _3090_ _3192_ VGND VGND VPWR VPWR _4132_ sky130_fd_sc_hd__nor2_2
X_5522_ regfile.registers\[12\]\[7\] regfile.registers\[13\]\[7\] regfile.registers\[14\]\[7\]
+ regfile.registers\[15\]\[7\] _2113_ _2114_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__mux4_1
X_9290_ clknet_leaf_107_CLK _0450_ VGND VGND VPWR VPWR regfile.registers\[25\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_119_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8241_ _4095_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__clkbuf_1
X_5453_ _1828_ _2208_ _1728_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__a21oi_1
X_8172_ net676 _3488_ _4024_ VGND VGND VPWR VPWR _4059_ sky130_fd_sc_hd__mux2_1
X_5384_ _1670_ _2131_ _2135_ _2139_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__a2bb2o_4
X_4404_ _1158_ _1159_ _1047_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__mux2_1
X_7123_ _3489_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
X_4335_ regfile.registers\[20\]\[3\] regfile.registers\[21\]\[3\] regfile.registers\[22\]\[3\]
+ regfile.registers\[23\]\[3\] _1089_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__mux4_1
X_7054_ net817 _3095_ _3449_ VGND VGND VPWR VPWR _3451_ sky130_fd_sc_hd__mux2_1
X_6005_ _2663_ _2712_ _2725_ _2689_ VGND VGND VPWR VPWR _2745_ sky130_fd_sc_hd__or4_4
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7956_ _3944_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__clkbuf_1
X_7887_ net156 _3544_ _3902_ VGND VGND VPWR VPWR _3908_ sky130_fd_sc_hd__mux2_1
X_6907_ net309 _3013_ _3362_ VGND VGND VPWR VPWR _3372_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6838_ _3083_ net599 _3325_ VGND VGND VPWR VPWR _3335_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9557_ clknet_leaf_30_CLK _0717_ VGND VGND VPWR VPWR regfile.registers\[11\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8508_ net270 net37 _4227_ VGND VGND VPWR VPWR _4237_ sky130_fd_sc_hd__mux2_1
X_6769_ _3298_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9488_ clknet_leaf_9_CLK _0648_ VGND VGND VPWR VPWR regfile.registers\[16\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_103_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8439_ _4200_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold270 regfile.registers\[2\]\[3\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
Xhold281 regfile.registers\[10\]\[23\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 regfile.registers\[3\]\[6\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_103_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload107 clknet_leaf_94_CLK VGND VGND VPWR VPWR clkload107/Y sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_24_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 A1[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_4
X_7810_ _3867_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__clkbuf_1
X_8790_ clknet_leaf_49_CLK _0974_ VGND VGND VPWR VPWR regfile.registers\[14\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_4953_ regfile.registers\[8\]\[23\] regfile.registers\[9\]\[23\] regfile.registers\[10\]\[23\]
+ regfile.registers\[11\]\[23\] _1705_ _1708_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__mux4_1
X_7741_ _3064_ net719 _3830_ VGND VGND VPWR VPWR _3831_ sky130_fd_sc_hd__mux2_1
X_7672_ _3771_ VGND VGND VPWR VPWR _3794_ sky130_fd_sc_hd__buf_4
XFILLER_0_52_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6623_ net121 _3143_ _3216_ VGND VGND VPWR VPWR _3221_ sky130_fd_sc_hd__mux2_1
X_9411_ clknet_leaf_89_CLK _0571_ VGND VGND VPWR VPWR regfile.registers\[1\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_4884_ net5 VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__inv_2
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6554_ _3075_ net644 _3177_ VGND VGND VPWR VPWR _3183_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9342_ clknet_leaf_72_CLK _0502_ VGND VGND VPWR VPWR regfile.registers\[20\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_6485_ net130 _3145_ _3135_ VGND VGND VPWR VPWR _3146_ sky130_fd_sc_hd__mux2_1
X_9273_ clknet_leaf_37_CLK _0433_ VGND VGND VPWR VPWR regfile.registers\[18\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_5505_ _2259_ _2260_ _2044_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8224_ net746 _3540_ _4083_ VGND VGND VPWR VPWR _4087_ sky130_fd_sc_hd__mux2_1
X_5436_ _1828_ _2191_ _1728_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8155_ _4050_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__clkbuf_1
X_5367_ _1671_ _2110_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__o21ai_4
X_8086_ net743 _3538_ _4011_ VGND VGND VPWR VPWR _4014_ sky130_fd_sc_hd__mux2_1
X_7106_ net34 VGND VGND VPWR VPWR _3478_ sky130_fd_sc_hd__buf_2
X_4318_ regfile.registers\[8\]\[5\] regfile.registers\[9\]\[5\] regfile.registers\[10\]\[5\]
+ regfile.registers\[11\]\[5\] net97 _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__mux4_1
X_5298_ regfile.registers\[8\]\[3\] regfile.registers\[9\]\[3\] regfile.registers\[10\]\[3\]
+ regfile.registers\[11\]\[3\] _2051_ _2053_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__mux4_1
X_7037_ net842 _3002_ _3434_ VGND VGND VPWR VPWR _3441_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8988_ clknet_leaf_43_CLK _0148_ VGND VGND VPWR VPWR regfile.registers\[7\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7939_ _3935_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6270_ _2991_ _2994_ VGND VGND VPWR VPWR _2995_ sky130_fd_sc_hd__xnor2_1
X_5221_ _1766_ _1976_ _1672_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5152_ _1906_ _1907_ _1745_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_75_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5083_ _1667_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_16_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8911_ clknet_leaf_2_CLK _0071_ VGND VGND VPWR VPWR regfile.registers\[19\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8842_ clknet_leaf_106_CLK _0002_ VGND VGND VPWR VPWR regfile.registers\[5\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8773_ clknet_leaf_64_CLK _0957_ VGND VGND VPWR VPWR regfile.registers\[14\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5985_ _2140_ _2711_ VGND VGND VPWR VPWR _2726_ sky130_fd_sc_hd__or2_1
X_7724_ _3048_ net1027 _3819_ VGND VGND VPWR VPWR _3822_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4936_ _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_25_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7655_ _3785_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
X_4867_ regfile.registers\[24\]\[18\] regfile.registers\[25\]\[18\] regfile.registers\[26\]\[18\]
+ regfile.registers\[27\]\[18\] net1141 _1202_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__mux4_1
X_7586_ _3046_ net1128 _3747_ VGND VGND VPWR VPWR _3749_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6606_ net457 _3126_ _3205_ VGND VGND VPWR VPWR _3212_ sky130_fd_sc_hd__mux2_1
X_9325_ clknet_leaf_94_CLK _0485_ VGND VGND VPWR VPWR regfile.registers\[21\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4798_ regfile.registers\[4\]\[10\] regfile.registers\[5\]\[10\] regfile.registers\[6\]\[10\]
+ regfile.registers\[7\]\[10\] _1104_ _1105_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__mux4_1
X_6537_ _3058_ net1058 _3166_ VGND VGND VPWR VPWR _3174_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6468_ net28 VGND VGND VPWR VPWR _3134_ sky130_fd_sc_hd__buf_2
X_9256_ clknet_leaf_101_CLK _0416_ VGND VGND VPWR VPWR regfile.registers\[18\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6399_ _3086_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__clkbuf_1
X_9187_ clknet_leaf_84_CLK _0347_ VGND VGND VPWR VPWR regfile.registers\[30\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_5419_ _1670_ _2166_ _2170_ _2174_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__a2bb2o_4
X_8207_ net548 _3523_ _4072_ VGND VGND VPWR VPWR _4078_ sky130_fd_sc_hd__mux2_1
X_8138_ _4041_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_7_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8069_ net853 _3521_ _4000_ VGND VGND VPWR VPWR _4005_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_43_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5770_ _2503_ _2520_ VGND VGND VPWR VPWR _2521_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4721_ regfile.registers\[0\]\[13\] regfile.registers\[1\]\[13\] regfile.registers\[2\]\[13\]
+ regfile.registers\[3\]\[13\] _1172_ _1279_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__mux4_1
XFILLER_0_127_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7440_ _3671_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
X_4652_ regfile.registers\[8\]\[7\] regfile.registers\[9\]\[7\] regfile.registers\[10\]\[7\]
+ regfile.registers\[11\]\[7\] _1290_ _1193_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__mux4_1
XFILLER_0_126_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput30 WD3[22] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9110_ clknet_leaf_51_CLK _0270_ VGND VGND VPWR VPWR regfile.registers\[27\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold803 regfile.registers\[21\]\[28\] VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__dlygate4sd3_1
X_4583_ _1335_ _1336_ _1337_ _1338_ _1189_ _1205_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_77_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput41 WD3[3] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dlymetal6s2s_1
X_7371_ _3634_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
Xhold825 regfile.registers\[15\]\[16\] VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__dlygate4sd3_1
X_6322_ _3034_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__clkbuf_1
Xhold814 regfile.registers\[27\]\[4\] VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__dlygate4sd3_1
Xhold836 regfile.registers\[14\]\[18\] VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dlygate4sd3_1
Xhold869 regfile.registers\[21\]\[23\] VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlygate4sd3_1
X_6253_ _2255_ _2910_ _2978_ VGND VGND VPWR VPWR _2979_ sky130_fd_sc_hd__o21ai_1
X_9041_ clknet_leaf_4_CLK _0201_ VGND VGND VPWR VPWR regfile.registers\[31\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold858 regfile.registers\[21\]\[3\] VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__dlygate4sd3_1
Xhold847 regfile.registers\[16\]\[5\] VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5204_ _1839_ _1959_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__nor2_1
X_6184_ _2408_ _2906_ _2907_ _2913_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__o22a_1
XFILLER_0_58_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5135_ regfile.registers\[8\]\[31\] regfile.registers\[9\]\[31\] regfile.registers\[10\]\[31\]
+ regfile.registers\[11\]\[31\] _1882_ _1884_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_4_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5066_ _1782_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_88_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8825_ clknet_leaf_48_CLK _1009_ VGND VGND VPWR VPWR regfile.registers\[6\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_8756_ clknet_leaf_41_CLK _0940_ VGND VGND VPWR VPWR regfile.registers\[8\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_5968_ net85 _1480_ net1148 _2411_ VGND VGND VPWR VPWR _2710_ sky130_fd_sc_hd__a31o_1
XFILLER_0_59_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7707_ _3031_ net735 _3808_ VGND VGND VPWR VPWR _3813_ sky130_fd_sc_hd__mux2_1
X_4919_ _1674_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_47_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5899_ _2642_ _2643_ VGND VGND VPWR VPWR _2644_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8687_ clknet_leaf_7_CLK _0871_ VGND VGND VPWR VPWR regfile.registers\[0\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_7638_ _3776_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7569_ _3029_ net1040 _3736_ VGND VGND VPWR VPWR _3740_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9308_ clknet_leaf_43_CLK _0468_ VGND VGND VPWR VPWR regfile.registers\[25\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_9239_ clknet_leaf_37_CLK _0399_ VGND VGND VPWR VPWR regfile.registers\[9\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6940_ net152 _3118_ _3387_ VGND VGND VPWR VPWR _3390_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6871_ _3353_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__clkbuf_1
X_9590_ clknet_leaf_49_CLK _0750_ VGND VGND VPWR VPWR regfile.registers\[10\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_5822_ _2474_ _2469_ _1126_ VGND VGND VPWR VPWR _2571_ sky130_fd_sc_hd__mux2_1
X_8610_ clknet_leaf_86_CLK _0794_ VGND VGND VPWR VPWR regfile.registers\[17\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5753_ _2496_ _2502_ _2504_ VGND VGND VPWR VPWR _2505_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8541_ net993 net20 _4244_ VGND VGND VPWR VPWR _4254_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4704_ regfile.registers\[8\]\[12\] regfile.registers\[9\]\[12\] regfile.registers\[10\]\[12\]
+ regfile.registers\[11\]\[12\] _1181_ _1183_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5684_ _1841_ _2347_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__or2b_1
XFILLER_0_60_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8472_ _4218_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__clkbuf_1
X_7423_ _3661_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
X_4635_ regfile.registers\[8\]\[6\] regfile.registers\[9\]\[6\] regfile.registers\[10\]\[6\]
+ regfile.registers\[11\]\[6\] _1290_ _1193_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__mux4_1
X_4566_ _1320_ _1321_ _1198_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__mux2_1
X_7354_ _3087_ net812 _3590_ VGND VGND VPWR VPWR _3625_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold611 regfile.registers\[24\]\[6\] VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlygate4sd3_1
Xhold600 regfile.registers\[12\]\[15\] VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dlygate4sd3_1
Xhold633 regfile.registers\[7\]\[21\] VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlygate4sd3_1
Xhold622 regfile.registers\[31\]\[28\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlygate4sd3_1
X_6305_ _3022_ VGND VGND VPWR VPWR _3023_ sky130_fd_sc_hd__buf_6
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold644 regfile.registers\[22\]\[0\] VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlygate4sd3_1
Xhold677 regfile.registers\[29\]\[24\] VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlygate4sd3_1
Xhold688 regfile.registers\[13\]\[24\] VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlygate4sd3_1
Xhold666 regfile.registers\[1\]\[23\] VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlygate4sd3_1
X_4497_ _1251_ _1252_ _1211_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__mux2_1
X_7285_ _3587_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
X_9024_ clknet_leaf_78_CLK _0184_ VGND VGND VPWR VPWR regfile.registers\[31\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold655 regfile.registers\[30\]\[4\] VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlygate4sd3_1
X_6236_ _1087_ _2960_ _2961_ _2962_ _1127_ VGND VGND VPWR VPWR _2963_ sky130_fd_sc_hd__a32o_1
Xhold699 regfile.registers\[15\]\[27\] VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6167_ _2105_ _2754_ _2897_ _1087_ VGND VGND VPWR VPWR _2898_ sky130_fd_sc_hd__o211a_1
XFILLER_0_85_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5118_ _1777_ _1865_ _1869_ _1873_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6098_ _2830_ _2832_ _2503_ VGND VGND VPWR VPWR _2833_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5049_ regfile.registers\[20\]\[18\] regfile.registers\[21\]\[18\] regfile.registers\[22\]\[18\]
+ regfile.registers\[23\]\[18\] _1719_ _1722_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8808_ clknet_leaf_100_CLK _0992_ VGND VGND VPWR VPWR regfile.registers\[6\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8739_ clknet_leaf_82_CLK _0923_ VGND VGND VPWR VPWR regfile.registers\[8\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone11 A2[0] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_105_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4420_ regfile.registers\[20\]\[29\] regfile.registers\[21\]\[29\] regfile.registers\[22\]\[29\]
+ regfile.registers\[23\]\[29\] _1173_ _1175_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__mux4_1
XFILLER_0_112_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4351_ _1034_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__buf_4
X_7070_ net258 _3111_ _3449_ VGND VGND VPWR VPWR _3459_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4282_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__buf_4
X_6021_ _2757_ _2731_ _2758_ _2759_ VGND VGND VPWR VPWR _2760_ sky130_fd_sc_hd__a211o_1
X_7972_ _3953_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6923_ net138 _3101_ _3376_ VGND VGND VPWR VPWR _3381_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6854_ _3344_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__clkbuf_1
X_5805_ _1666_ _2554_ VGND VGND VPWR VPWR _2555_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6785_ _3307_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__clkbuf_1
X_9573_ clknet_leaf_64_CLK _0733_ VGND VGND VPWR VPWR regfile.registers\[10\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_5736_ _2040_ _2486_ _2487_ _1962_ VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__o22a_1
XFILLER_0_17_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8524_ _4245_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5667_ _2333_ VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__buf_2
XFILLER_0_17_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8455_ _4209_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4618_ regfile.registers\[20\]\[24\] regfile.registers\[21\]\[24\] regfile.registers\[22\]\[24\]
+ regfile.registers\[23\]\[24\] _1360_ _1361_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__mux4_1
X_7406_ _3071_ net806 _3649_ VGND VGND VPWR VPWR _3653_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5598_ _1668_ _2247_ VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__or2_1
X_8386_ net822 _3498_ _4169_ VGND VGND VPWR VPWR _4173_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold430 regfile.registers\[19\]\[29\] VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__dlygate4sd3_1
X_4549_ _1303_ _1304_ _1259_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_96_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7337_ _3616_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
Xhold452 regfile.registers\[0\]\[22\] VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__dlygate4sd3_1
Xhold441 regfile.registers\[8\]\[26\] VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__dlygate4sd3_1
Xhold463 regfile.registers\[11\]\[2\] VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__dlygate4sd3_1
X_7268_ net645 _3540_ _3575_ VGND VGND VPWR VPWR _3579_ sky130_fd_sc_hd__mux2_1
Xhold474 regfile.registers\[23\]\[31\] VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold496 regfile.registers\[10\]\[17\] VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__dlygate4sd3_1
Xhold485 regfile.registers\[12\]\[18\] VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__dlygate4sd3_1
X_6219_ _2105_ _2802_ _2946_ _1085_ VGND VGND VPWR VPWR _2947_ sky130_fd_sc_hd__o211a_1
X_9007_ clknet_leaf_110_CLK _0167_ VGND VGND VPWR VPWR regfile.registers\[29\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_7199_ _3541_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload19 clknet_leaf_109_CLK VGND VGND VPWR VPWR clkload19/Y sky130_fd_sc_hd__inv_8
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_121_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6570_ _3191_ VGND VGND VPWR VPWR _3192_ sky130_fd_sc_hd__buf_4
X_5521_ _2273_ _2274_ _2275_ _2276_ _1711_ _1716_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__mux4_1
XFILLER_0_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8240_ net507 _3488_ _4060_ VGND VGND VPWR VPWR _4095_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5452_ _2206_ _2207_ _1738_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__mux2_1
X_8171_ _4058_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5383_ _1828_ _2138_ _1728_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__a21oi_1
X_4403_ regfile.registers\[12\]\[0\] regfile.registers\[13\]\[0\] regfile.registers\[14\]\[0\]
+ regfile.registers\[15\]\[0\] _1149_ _1028_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__mux4_1
XFILLER_0_112_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7122_ net956 _3488_ _3448_ VGND VGND VPWR VPWR _3489_ sky130_fd_sc_hd__mux2_1
X_4334_ _1043_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7053_ _3450_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6004_ _1874_ _2743_ VGND VGND VPWR VPWR _2744_ sky130_fd_sc_hd__xor2_1
X_7955_ _3145_ net1076 _3938_ VGND VGND VPWR VPWR _3944_ sky130_fd_sc_hd__mux2_1
X_7886_ _3907_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__clkbuf_1
X_6906_ _3371_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__clkbuf_1
X_6837_ _3334_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9556_ clknet_leaf_23_CLK _0716_ VGND VGND VPWR VPWR regfile.registers\[11\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_6768_ net536 _3011_ _3289_ VGND VGND VPWR VPWR _3298_ sky130_fd_sc_hd__mux2_1
X_8507_ _4236_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_122_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5719_ _2347_ _1169_ _1905_ VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__and3_1
X_6699_ _3261_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9487_ clknet_leaf_1_CLK _0647_ VGND VGND VPWR VPWR regfile.registers\[16\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_8438_ net321 net36 _4191_ VGND VGND VPWR VPWR _4200_ sky130_fd_sc_hd__mux2_1
X_8369_ _4163_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__clkbuf_1
Xhold271 regfile.registers\[10\]\[21\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_103_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold260 regfile.registers\[7\]\[13\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 regfile.registers\[24\]\[27\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 regfile.registers\[25\]\[22\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_103_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput6 A2[2] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_0_99_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4952_ _1707_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__buf_4
X_7740_ _3807_ VGND VGND VPWR VPWR _3830_ sky130_fd_sc_hd__buf_6
X_4883_ _1638_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__buf_4
X_7671_ _3793_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_738 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6622_ _3220_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__clkbuf_1
X_9410_ clknet_leaf_88_CLK _0570_ VGND VGND VPWR VPWR regfile.registers\[1\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_6553_ _3182_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_104_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9341_ clknet_leaf_12_CLK _0501_ VGND VGND VPWR VPWR regfile.registers\[21\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6484_ net33 VGND VGND VPWR VPWR _3145_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_89_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9272_ clknet_leaf_23_CLK _0432_ VGND VGND VPWR VPWR regfile.registers\[18\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_5504_ regfile.registers\[24\]\[6\] regfile.registers\[25\]\[6\] regfile.registers\[26\]\[6\]
+ regfile.registers\[27\]\[6\] _1733_ _1679_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__mux4_1
XFILLER_0_124_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8223_ _4086_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__clkbuf_1
X_5435_ _2189_ _2190_ _1738_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8154_ net831 _3538_ _4047_ VGND VGND VPWR VPWR _4050_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5366_ _2112_ _2116_ _2121_ _1828_ _1728_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__a221o_1
X_7105_ _3477_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_8085_ _4013_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__clkbuf_1
X_4317_ _1043_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__buf_4
X_5297_ _2052_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__clkbuf_4
X_7036_ _3440_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_98_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8987_ clknet_leaf_38_CLK _0147_ VGND VGND VPWR VPWR regfile.registers\[7\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_7938_ _3128_ net918 _3927_ VGND VGND VPWR VPWR _3935_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7869_ _3898_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9539_ clknet_leaf_89_CLK _0699_ VGND VGND VPWR VPWR regfile.registers\[11\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_123_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5220_ _1974_ _1975_ _1745_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5151_ regfile.registers\[16\]\[30\] regfile.registers\[17\]\[30\] regfile.registers\[18\]\[30\]
+ regfile.registers\[19\]\[30\] _1895_ _1897_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_75_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5082_ _1671_ _1829_ _1833_ _1837_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__a2bb2o_4
X_8910_ clknet_leaf_4_CLK _0070_ VGND VGND VPWR VPWR regfile.registers\[19\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8841_ clknet_leaf_96_CLK _0001_ VGND VGND VPWR VPWR regfile.registers\[5\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_127_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8772_ clknet_leaf_91_CLK _0956_ VGND VGND VPWR VPWR regfile.registers\[14\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5984_ _2724_ _2123_ VGND VGND VPWR VPWR _2725_ sky130_fd_sc_hd__xnor2_1
X_7723_ _3821_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_129_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4935_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__buf_4
X_7654_ net771 _3515_ _3783_ VGND VGND VPWR VPWR _3785_ sky130_fd_sc_hd__mux2_1
X_4866_ regfile.registers\[28\]\[18\] regfile.registers\[29\]\[18\] regfile.registers\[30\]\[18\]
+ regfile.registers\[31\]\[18\] net1141 _1202_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__mux4_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7585_ _3748_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4797_ _1038_ _1552_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__nand2_1
X_6605_ _3211_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__clkbuf_1
X_6536_ _3173_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__clkbuf_1
X_9324_ clknet_leaf_111_CLK _0484_ VGND VGND VPWR VPWR regfile.registers\[21\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6467_ _3133_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__clkbuf_1
X_9255_ clknet_leaf_62_CLK _0415_ VGND VGND VPWR VPWR regfile.registers\[18\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_6398_ _3085_ net802 _3022_ VGND VGND VPWR VPWR _3086_ sky130_fd_sc_hd__mux2_1
X_9186_ clknet_leaf_86_CLK _0346_ VGND VGND VPWR VPWR regfile.registers\[30\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_5418_ _1828_ _2173_ _1728_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__a21oi_1
X_8206_ _4077_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__clkbuf_1
X_5349_ _2104_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__clkbuf_4
X_8137_ net491 _3521_ _4036_ VGND VGND VPWR VPWR _4041_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8068_ _4004_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__clkbuf_1
X_7019_ _3431_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4720_ regfile.registers\[4\]\[13\] regfile.registers\[5\]\[13\] regfile.registers\[6\]\[13\]
+ regfile.registers\[7\]\[13\] _1172_ _1279_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__mux4_1
XFILLER_0_127_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_123_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4651_ regfile.registers\[12\]\[7\] regfile.registers\[13\]\[7\] regfile.registers\[14\]\[7\]
+ regfile.registers\[15\]\[7\] _1290_ _1193_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__mux4_1
Xinput31 WD3[23] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
XFILLER_0_71_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput20 WD3[13] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
X_4582_ regfile.registers\[20\]\[30\] regfile.registers\[21\]\[30\] regfile.registers\[22\]\[30\]
+ regfile.registers\[23\]\[30\] _1267_ _1268_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_77_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput42 WD3[4] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7370_ _3035_ net1001 _3627_ VGND VGND VPWR VPWR _3634_ sky130_fd_sc_hd__mux2_1
Xhold804 regfile.registers\[23\]\[27\] VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__dlygate4sd3_1
Xhold826 regfile.registers\[13\]\[26\] VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6321_ _3033_ net1118 _3023_ VGND VGND VPWR VPWR _3034_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold815 regfile.registers\[14\]\[6\] VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold837 regfile.registers\[28\]\[16\] VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlygate4sd3_1
Xhold848 regfile.registers\[21\]\[21\] VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_122_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6252_ _2104_ _2849_ _2977_ _1086_ VGND VGND VPWR VPWR _2978_ sky130_fd_sc_hd__o211a_1
Xhold859 regfile.registers\[30\]\[5\] VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__dlygate4sd3_1
X_9040_ clknet_leaf_8_CLK _0200_ VGND VGND VPWR VPWR regfile.registers\[31\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_5203_ _1842_ _1958_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__nor2_2
X_6183_ _2504_ _2908_ _2912_ VGND VGND VPWR VPWR _2913_ sky130_fd_sc_hd__or3_1
X_5134_ _1885_ _1886_ _1887_ _1888_ _1889_ _1773_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__mux4_1
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5065_ _1758_ _1820_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_88_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8824_ clknet_leaf_18_CLK _1008_ VGND VGND VPWR VPWR regfile.registers\[6\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_8755_ clknet_leaf_35_CLK _0939_ VGND VGND VPWR VPWR regfile.registers\[8\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5967_ _2550_ _2591_ _2708_ VGND VGND VPWR VPWR _2709_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4918_ _1673_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__clkbuf_8
X_7706_ _3812_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__clkbuf_1
X_8686_ clknet_leaf_6_CLK _0870_ VGND VGND VPWR VPWR regfile.registers\[0\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5898_ _2193_ _2640_ _2641_ VGND VGND VPWR VPWR _2643_ sky130_fd_sc_hd__nand3_1
X_7637_ net350 _3498_ _3772_ VGND VGND VPWR VPWR _3776_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4849_ _1603_ _1604_ _1178_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7568_ _3739_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_120_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9307_ clknet_leaf_26_CLK _0467_ VGND VGND VPWR VPWR regfile.registers\[25\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_6519_ _3164_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__clkbuf_1
X_7499_ _3027_ net1082 _3700_ VGND VGND VPWR VPWR _3703_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9238_ clknet_leaf_50_CLK _0398_ VGND VGND VPWR VPWR regfile.registers\[9\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_9169_ clknet_leaf_18_CLK _0329_ VGND VGND VPWR VPWR regfile.registers\[2\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_113_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6870_ net781 _3116_ _3351_ VGND VGND VPWR VPWR _3353_ sky130_fd_sc_hd__mux2_1
X_5821_ _2039_ _2251_ VGND VGND VPWR VPWR _2570_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5752_ _2503_ VGND VGND VPWR VPWR _2504_ sky130_fd_sc_hd__buf_2
X_8540_ _4253_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__clkbuf_1
X_4703_ _1287_ _1458_ _1088_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5683_ _2036_ _1757_ _2347_ VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__mux2_2
XFILLER_0_71_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8471_ net672 net18 _4216_ VGND VGND VPWR VPWR _4218_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7422_ _3087_ net547 _3626_ VGND VGND VPWR VPWR _3661_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4634_ _1386_ _1387_ _1388_ _1389_ _1048_ _1088_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__mux4_2
Xhold612 regfile.registers\[31\]\[25\] VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlygate4sd3_1
Xhold601 regfile.registers\[16\]\[29\] VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlygate4sd3_1
X_7353_ _3624_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
X_4565_ regfile.registers\[24\]\[31\] regfile.registers\[25\]\[31\] regfile.registers\[26\]\[31\]
+ regfile.registers\[27\]\[31\] _1200_ _1202_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold645 regfile.registers\[16\]\[22\] VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlygate4sd3_1
Xhold634 regfile.registers\[4\]\[30\] VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6304_ _3020_ _3021_ VGND VGND VPWR VPWR _3022_ sky130_fd_sc_hd__nand2_4
Xhold623 regfile.registers\[8\]\[4\] VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold667 regfile.registers\[16\]\[26\] VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlygate4sd3_1
X_4496_ regfile.registers\[0\]\[20\] regfile.registers\[1\]\[20\] regfile.registers\[2\]\[20\]
+ regfile.registers\[3\]\[20\] _1192_ _1195_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__mux4_1
X_7284_ net134 _3488_ _3552_ VGND VGND VPWR VPWR _3587_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold678 regfile.registers\[22\]\[8\] VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlygate4sd3_1
Xhold656 regfile.registers\[30\]\[14\] VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlygate4sd3_1
X_9023_ clknet_leaf_79_CLK _0183_ VGND VGND VPWR VPWR regfile.registers\[31\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6235_ _2102_ _2692_ VGND VGND VPWR VPWR _2962_ sky130_fd_sc_hd__nor2_1
Xhold689 regfile.registers\[14\]\[17\] VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__dlygate4sd3_1
X_6166_ _2255_ _2821_ _2896_ _2337_ VGND VGND VPWR VPWR _2897_ sky130_fd_sc_hd__o22a_1
X_6097_ _2806_ _2827_ VGND VGND VPWR VPWR _2832_ sky130_fd_sc_hd__nor2_1
X_5117_ _1700_ _1872_ _1671_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__o21ai_1
X_5048_ _1757_ _1802_ _1803_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__mux2_1
XFILLER_0_95_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8807_ clknet_leaf_63_CLK _0991_ VGND VGND VPWR VPWR regfile.registers\[6\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6999_ net765 _3109_ _3412_ VGND VGND VPWR VPWR _3421_ sky130_fd_sc_hd__mux2_1
X_8738_ clknet_leaf_89_CLK _0922_ VGND VGND VPWR VPWR regfile.registers\[8\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8669_ clknet_leaf_12_CLK _0853_ VGND VGND VPWR VPWR regfile.registers\[22\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4350_ regfile.registers\[0\]\[3\] regfile.registers\[1\]\[3\] regfile.registers\[2\]\[3\]
+ regfile.registers\[3\]\[3\] _1104_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4281_ net7 VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__buf_4
X_6020_ _2102_ _2406_ VGND VGND VPWR VPWR _2759_ sky130_fd_sc_hd__nor2_1
X_7971_ _3089_ net899 _3952_ VGND VGND VPWR VPWR _3953_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_85_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6922_ _3380_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__clkbuf_1
X_6853_ net392 _3099_ _3340_ VGND VGND VPWR VPWR _3344_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5804_ _2442_ _2487_ _2553_ _2040_ VGND VGND VPWR VPWR _2554_ sky130_fd_sc_hd__o22a_1
XFILLER_0_71_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6784_ _3029_ net850 _3303_ VGND VGND VPWR VPWR _3307_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9572_ clknet_leaf_90_CLK _0732_ VGND VGND VPWR VPWR regfile.registers\[10\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_5735_ _2039_ _2251_ VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__nand2_1
X_8523_ net199 net42 _4244_ VGND VGND VPWR VPWR _4245_ sky130_fd_sc_hd__mux2_1
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5666_ _2363_ _2417_ _2419_ VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8454_ net366 net41 _4205_ VGND VGND VPWR VPWR _4209_ sky130_fd_sc_hd__mux2_1
X_4617_ regfile.registers\[16\]\[24\] regfile.registers\[17\]\[24\] regfile.registers\[18\]\[24\]
+ regfile.registers\[19\]\[24\] _1360_ _1361_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__mux4_1
XFILLER_0_115_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7405_ _3652_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_96_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5597_ _1839_ _2211_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__nand2_1
X_8385_ _4172_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__clkbuf_1
Xhold420 regfile.registers\[19\]\[6\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlygate4sd3_1
X_4548_ regfile.registers\[24\]\[27\] regfile.registers\[25\]\[27\] regfile.registers\[26\]\[27\]
+ regfile.registers\[27\]\[27\] _1262_ _1263_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_96_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7336_ _3069_ net885 _3613_ VGND VGND VPWR VPWR _3616_ sky130_fd_sc_hd__mux2_1
Xhold453 regfile.registers\[22\]\[15\] VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__dlygate4sd3_1
Xhold431 regfile.registers\[25\]\[11\] VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlygate4sd3_1
Xhold442 regfile.registers\[19\]\[2\] VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__dlygate4sd3_1
Xhold486 regfile.registers\[11\]\[28\] VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__dlygate4sd3_1
X_4479_ _1233_ _1234_ _1189_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__mux2_1
X_7267_ _3578_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
Xhold464 regfile.registers\[2\]\[17\] VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__dlygate4sd3_1
Xhold475 regfile.registers\[11\]\[7\] VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd3_1
X_6218_ _2255_ _2867_ _2945_ _2337_ VGND VGND VPWR VPWR _2946_ sky130_fd_sc_hd__o22a_1
Xhold497 regfile.registers\[4\]\[12\] VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__dlygate4sd3_1
X_9006_ clknet_leaf_3_CLK _0166_ VGND VGND VPWR VPWR regfile.registers\[29\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_7198_ net265 _3540_ _3534_ VGND VGND VPWR VPWR _3541_ sky130_fd_sc_hd__mux2_1
X_6149_ _1731_ _2853_ VGND VGND VPWR VPWR _2881_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_109_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_118_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_127_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_121_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5520_ regfile.registers\[20\]\[7\] regfile.registers\[21\]\[7\] regfile.registers\[22\]\[7\]
+ regfile.registers\[23\]\[7\] _2051_ _2053_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__mux4_1
XFILLER_0_81_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5451_ regfile.registers\[0\]\[10\] regfile.registers\[1\]\[10\] regfile.registers\[2\]\[10\]
+ regfile.registers\[3\]\[10\] _1718_ _1721_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__mux4_1
XFILLER_0_124_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8170_ net310 _3486_ _4024_ VGND VGND VPWR VPWR _4058_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5382_ _2136_ _2137_ _1738_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__mux2_1
X_4402_ regfile.registers\[8\]\[0\] regfile.registers\[9\]\[0\] regfile.registers\[10\]\[0\]
+ regfile.registers\[11\]\[0\] _1104_ _1105_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__mux4_1
X_7121_ net40 VGND VGND VPWR VPWR _3488_ sky130_fd_sc_hd__buf_2
X_4333_ _1041_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__buf_12
X_7052_ net529 _3089_ _3449_ VGND VGND VPWR VPWR _3450_ sky130_fd_sc_hd__mux2_1
X_6003_ _1587_ _2742_ VGND VGND VPWR VPWR _2743_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7954_ _3943_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__clkbuf_1
X_6905_ net834 _3011_ _3362_ VGND VGND VPWR VPWR _3371_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7885_ net224 _3542_ _3902_ VGND VGND VPWR VPWR _3907_ sky130_fd_sc_hd__mux2_1
X_6836_ _3081_ net1092 _3325_ VGND VGND VPWR VPWR _3334_ sky130_fd_sc_hd__mux2_1
XFILLER_0_119_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9555_ clknet_leaf_33_CLK _0715_ VGND VGND VPWR VPWR regfile.registers\[11\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_6767_ _3297_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5718_ _2469_ _2470_ _2251_ VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8506_ net566 net36 _4227_ VGND VGND VPWR VPWR _4236_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6698_ _3079_ net779 _3253_ VGND VGND VPWR VPWR _3261_ sky130_fd_sc_hd__mux2_1
X_9486_ clknet_leaf_3_CLK _0646_ VGND VGND VPWR VPWR regfile.registers\[16\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8437_ _4199_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__clkbuf_1
X_5649_ _2397_ _2403_ net84 VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8368_ net625 _3480_ _4155_ VGND VGND VPWR VPWR _4163_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold250 regfile.registers\[1\]\[9\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7319_ _3052_ net215 _3602_ VGND VGND VPWR VPWR _3607_ sky130_fd_sc_hd__mux2_1
Xhold261 regfile.registers\[15\]\[4\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8299_ _4126_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__clkbuf_1
Xhold272 regfile.registers\[24\]\[11\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 regfile.registers\[21\]\[6\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold294 regfile.registers\[18\]\[18\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_108_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_108_CLK
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_127_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput7 A2[3] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4951_ _1706_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__buf_4
XFILLER_0_129_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4882_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__buf_6
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7670_ net1104 _3531_ _3783_ VGND VGND VPWR VPWR _3793_ sky130_fd_sc_hd__mux2_1
X_6621_ net587 _3141_ _3216_ VGND VGND VPWR VPWR _3220_ sky130_fd_sc_hd__mux2_1
X_9340_ clknet_leaf_43_CLK _0500_ VGND VGND VPWR VPWR regfile.registers\[21\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6552_ _3073_ net408 _3177_ VGND VGND VPWR VPWR _3182_ sky130_fd_sc_hd__mux2_1
XFILLER_0_116_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6483_ _3144_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_125_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9271_ clknet_leaf_36_CLK _0431_ VGND VGND VPWR VPWR regfile.registers\[18\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5503_ regfile.registers\[28\]\[6\] regfile.registers\[29\]\[6\] regfile.registers\[30\]\[6\]
+ regfile.registers\[31\]\[6\] _1733_ _1679_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__mux4_1
X_8222_ net512 _3538_ _4083_ VGND VGND VPWR VPWR _4086_ sky130_fd_sc_hd__mux2_1
X_5434_ regfile.registers\[0\]\[11\] regfile.registers\[1\]\[11\] regfile.registers\[2\]\[11\]
+ regfile.registers\[3\]\[11\] _1703_ _1706_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8153_ _4049_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7104_ net191 _3145_ _3471_ VGND VGND VPWR VPWR _3477_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5365_ _2119_ _2120_ _1738_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__mux2_1
X_8084_ net194 _3536_ _4011_ VGND VGND VPWR VPWR _4013_ sky130_fd_sc_hd__mux2_1
X_5296_ _1690_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__clkbuf_4
X_4316_ _1041_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__buf_12
X_7035_ net124 _3145_ _3434_ VGND VGND VPWR VPWR _3440_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8986_ clknet_leaf_40_CLK _0146_ VGND VGND VPWR VPWR regfile.registers\[7\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_96_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7937_ _3934_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7868_ net519 _3525_ _3891_ VGND VGND VPWR VPWR _3898_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6819_ _3302_ VGND VGND VPWR VPWR _3325_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_41_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7799_ _3861_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__clkbuf_1
X_9538_ clknet_leaf_87_CLK _0698_ VGND VGND VPWR VPWR regfile.registers\[11\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_21_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9469_ clknet_leaf_14_CLK _0629_ VGND VGND VPWR VPWR regfile.registers\[13\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5150_ regfile.registers\[20\]\[30\] regfile.registers\[21\]\[30\] regfile.registers\[22\]\[30\]
+ regfile.registers\[23\]\[30\] _1895_ _1897_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_75_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5081_ _1717_ _1836_ _1729_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8840_ clknet_leaf_100_CLK _0000_ VGND VGND VPWR VPWR regfile.registers\[5\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5983_ _1511_ _2723_ VGND VGND VPWR VPWR _2724_ sky130_fd_sc_hd__xnor2_2
X_8771_ clknet_leaf_83_CLK _0955_ VGND VGND VPWR VPWR regfile.registers\[14\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7722_ _3046_ net1056 _3819_ VGND VGND VPWR VPWR _3821_ sky130_fd_sc_hd__mux2_1
X_4934_ _1642_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_129_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7653_ _3784_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__clkbuf_1
X_4865_ _1619_ _1620_ _1259_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__mux2_1
XFILLER_0_117_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6604_ net182 _3124_ _3205_ VGND VGND VPWR VPWR _3211_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7584_ _3043_ net654 _3747_ VGND VGND VPWR VPWR _3748_ sky130_fd_sc_hd__mux2_1
X_4796_ _1550_ _1551_ _1047_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__mux2_1
X_6535_ _3056_ net888 _3166_ VGND VGND VPWR VPWR _3173_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9323_ clknet_leaf_104_CLK _0483_ VGND VGND VPWR VPWR regfile.registers\[21\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9254_ clknet_leaf_69_CLK _0414_ VGND VGND VPWR VPWR regfile.registers\[18\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6466_ net391 _3132_ _3114_ VGND VGND VPWR VPWR _3133_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8205_ net185 _3521_ _4072_ VGND VGND VPWR VPWR _4077_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6397_ net39 VGND VGND VPWR VPWR _3085_ sky130_fd_sc_hd__clkbuf_2
X_9185_ clknet_leaf_85_CLK _0345_ VGND VGND VPWR VPWR regfile.registers\[30\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_5417_ _2171_ _2172_ _1738_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__mux2_1
X_5348_ _1111_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8136_ _4040_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__clkbuf_1
X_8067_ net684 _3519_ _4000_ VGND VGND VPWR VPWR _4004_ sky130_fd_sc_hd__mux2_1
X_5279_ _1799_ _2034_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__and2_1
X_7018_ net889 _3128_ _3423_ VGND VGND VPWR VPWR _3431_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8969_ clknet_leaf_96_CLK _0129_ VGND VGND VPWR VPWR regfile.registers\[7\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4650_ _1402_ _1405_ _1038_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__mux2_2
XFILLER_0_126_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput10 A3[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_2
Xinput21 WD3[14] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
Xinput32 WD3[24] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dlymetal6s2s_1
X_4581_ regfile.registers\[16\]\[30\] regfile.registers\[17\]\[30\] regfile.registers\[18\]\[30\]
+ regfile.registers\[19\]\[30\] _1267_ _1268_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_77_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput43 WD3[5] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6320_ net43 VGND VGND VPWR VPWR _3033_ sky130_fd_sc_hd__clkbuf_2
Xhold805 regfile.registers\[29\]\[22\] VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold827 regfile.registers\[28\]\[4\] VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__dlygate4sd3_1
Xhold816 regfile.registers\[28\]\[0\] VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6251_ _1944_ _2975_ _2976_ VGND VGND VPWR VPWR _2977_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_90_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold849 regfile.registers\[31\]\[7\] VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold838 regfile.registers\[25\]\[17\] VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_30_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_30_CLK sky130_fd_sc_hd__clkbuf_8
X_5202_ _1777_ _1949_ _1957_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__a21oi_4
X_6182_ _2530_ _2779_ _2911_ _1087_ VGND VGND VPWR VPWR _2912_ sky130_fd_sc_hd__o211a_1
X_5133_ _1713_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_4_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5064_ _1671_ _1811_ _1815_ _1819_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__a2bb2o_4
X_8823_ clknet_leaf_50_CLK _1007_ VGND VGND VPWR VPWR regfile.registers\[6\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_88_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5966_ _2553_ _2588_ _2679_ _2442_ _2333_ VGND VGND VPWR VPWR _2708_ sky130_fd_sc_hd__o221a_1
X_8754_ clknet_leaf_60_CLK _0938_ VGND VGND VPWR VPWR regfile.registers\[8\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_97_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_97_CLK sky130_fd_sc_hd__clkbuf_8
X_5897_ _2640_ _2641_ _2193_ VGND VGND VPWR VPWR _2642_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8685_ clknet_leaf_93_CLK _0869_ VGND VGND VPWR VPWR regfile.registers\[0\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_7705_ _3029_ net901 _3808_ VGND VGND VPWR VPWR _3812_ sky130_fd_sc_hd__mux2_1
X_4917_ _1641_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__buf_4
XFILLER_0_118_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4848_ regfile.registers\[16\]\[19\] regfile.registers\[17\]\[19\] regfile.registers\[18\]\[19\]
+ regfile.registers\[19\]\[19\] net1150 _1222_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux4_1
X_7636_ _3775_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9306_ clknet_leaf_24_CLK _0466_ VGND VGND VPWR VPWR regfile.registers\[25\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_4779_ _1047_ _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__or2_1
X_7567_ _3027_ net1100 _3736_ VGND VGND VPWR VPWR _3739_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6518_ _3039_ net758 _3155_ VGND VGND VPWR VPWR _3164_ sky130_fd_sc_hd__mux2_1
X_7498_ _3702_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9237_ clknet_leaf_31_CLK _0397_ VGND VGND VPWR VPWR regfile.registers\[9\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_6449_ _3121_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_21_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_21_CLK sky130_fd_sc_hd__clkbuf_8
X_9168_ clknet_leaf_10_CLK _0328_ VGND VGND VPWR VPWR regfile.registers\[2\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_8119_ _4031_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__clkbuf_1
X_9099_ clknet_leaf_104_CLK _0259_ VGND VGND VPWR VPWR regfile.registers\[27\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_88_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_88_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_109_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_113_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_12_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_12_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_124_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5820_ _2568_ VGND VGND VPWR VPWR _2569_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_79_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_79_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_91_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5751_ net15 VGND VGND VPWR VPWR _2503_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8470_ _4217_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__clkbuf_1
X_4702_ regfile.registers\[0\]\[12\] regfile.registers\[1\]\[12\] regfile.registers\[2\]\[12\]
+ regfile.registers\[3\]\[12\] _1191_ _1174_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__mux4_1
XFILLER_0_127_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5682_ _2105_ _2427_ _2435_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__o21a_1
X_7421_ _3660_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4633_ regfile.registers\[20\]\[6\] regfile.registers\[21\]\[6\] regfile.registers\[22\]\[6\]
+ regfile.registers\[23\]\[6\] _1219_ _1221_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__mux4_2
X_7352_ _3085_ net586 _3590_ VGND VGND VPWR VPWR _3624_ sky130_fd_sc_hd__mux2_1
X_4564_ regfile.registers\[28\]\[31\] regfile.registers\[29\]\[31\] regfile.registers\[30\]\[31\]
+ regfile.registers\[31\]\[31\] _1200_ _1202_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__mux4_1
XFILLER_0_25_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold602 regfile.registers\[25\]\[6\] VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dlygate4sd3_1
Xhold613 regfile.registers\[5\]\[21\] VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlygate4sd3_1
Xhold624 regfile.registers\[4\]\[29\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dlygate4sd3_1
X_7283_ _3586_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
X_6303_ net10 net9 net48 VGND VGND VPWR VPWR _3021_ sky130_fd_sc_hd__and3_4
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold635 regfile.registers\[4\]\[3\] VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlygate4sd3_1
Xhold679 regfile.registers\[4\]\[21\] VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlygate4sd3_1
X_6234_ _1111_ _2822_ _2896_ _2254_ VGND VGND VPWR VPWR _2961_ sky130_fd_sc_hd__o22a_1
XFILLER_0_100_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4495_ regfile.registers\[4\]\[20\] regfile.registers\[5\]\[20\] regfile.registers\[6\]\[20\]
+ regfile.registers\[7\]\[20\] _1192_ _1195_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__mux4_1
XFILLER_0_69_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold668 regfile.registers\[10\]\[10\] VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlygate4sd3_1
Xhold657 regfile.registers\[5\]\[3\] VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlygate4sd3_1
X_9022_ clknet_leaf_72_CLK _0182_ VGND VGND VPWR VPWR regfile.registers\[31\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold646 regfile.registers\[27\]\[0\] VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6165_ _2857_ _2895_ _2327_ VGND VGND VPWR VPWR _2896_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6096_ _2830_ VGND VGND VPWR VPWR _2831_ sky130_fd_sc_hd__inv_2
X_5116_ _1870_ _1871_ _1726_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__mux2_1
X_5047_ _1145_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__clkbuf_4
X_8806_ clknet_leaf_56_CLK _0990_ VGND VGND VPWR VPWR regfile.registers\[6\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6998_ _3420_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5949_ _2378_ _2381_ _2178_ VGND VGND VPWR VPWR _2692_ sky130_fd_sc_hd__mux2_1
X_8737_ clknet_leaf_82_CLK _0921_ VGND VGND VPWR VPWR regfile.registers\[8\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8668_ clknet_leaf_43_CLK _0852_ VGND VGND VPWR VPWR regfile.registers\[22\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_8599_ clknet_leaf_35_CLK _0783_ VGND VGND VPWR VPWR regfile.registers\[23\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_7619_ _3079_ net742 _3758_ VGND VGND VPWR VPWR _3766_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_1_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_1_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_54_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4280_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_39_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7970_ _3951_ VGND VGND VPWR VPWR _3952_ sky130_fd_sc_hd__buf_6
XFILLER_0_55_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6921_ net737 _3099_ _3376_ VGND VGND VPWR VPWR _3380_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6852_ _3343_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__clkbuf_1
X_5803_ _2443_ _2437_ _1879_ VGND VGND VPWR VPWR _2553_ sky130_fd_sc_hd__mux2_2
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9571_ clknet_leaf_89_CLK _0731_ VGND VGND VPWR VPWR regfile.registers\[10\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8522_ _3006_ VGND VGND VPWR VPWR _4244_ sky130_fd_sc_hd__clkbuf_8
X_6783_ _3306_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__clkbuf_1
X_5734_ _2037_ _1804_ _2251_ VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__mux2_2
XFILLER_0_84_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5665_ _1147_ _2418_ VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8453_ _4208_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__clkbuf_1
X_4616_ regfile.registers\[28\]\[24\] regfile.registers\[29\]\[24\] regfile.registers\[30\]\[24\]
+ regfile.registers\[31\]\[24\] _1360_ _1361_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__mux4_1
X_7404_ _3069_ net851 _3649_ VGND VGND VPWR VPWR _3652_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8384_ net157 _3496_ _4169_ VGND VGND VPWR VPWR _4172_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold410 regfile.registers\[21\]\[24\] VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlygate4sd3_1
X_7335_ _3615_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5596_ _2349_ _2350_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4547_ regfile.registers\[28\]\[27\] regfile.registers\[29\]\[27\] regfile.registers\[30\]\[27\]
+ regfile.registers\[31\]\[27\] _1262_ _1263_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_96_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold432 regfile.registers\[1\]\[22\] VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlygate4sd3_1
Xhold421 regfile.registers\[8\]\[31\] VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlygate4sd3_1
Xhold454 regfile.registers\[18\]\[0\] VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__dlygate4sd3_1
Xhold443 regfile.registers\[27\]\[13\] VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold465 regfile.registers\[17\]\[29\] VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__dlygate4sd3_1
X_4478_ regfile.registers\[12\]\[28\] regfile.registers\[13\]\[28\] regfile.registers\[14\]\[28\]
+ regfile.registers\[15\]\[28\] _1182_ _1184_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__mux4_1
X_7266_ net176 _3538_ _3575_ VGND VGND VPWR VPWR _3578_ sky130_fd_sc_hd__mux2_1
Xhold476 regfile.registers\[10\]\[26\] VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlygate4sd3_1
Xhold487 regfile.registers\[14\]\[5\] VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd3_1
Xhold498 regfile.registers\[16\]\[25\] VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__dlygate4sd3_1
X_7197_ net31 VGND VGND VPWR VPWR _3540_ sky130_fd_sc_hd__buf_2
X_6217_ _2909_ _2944_ _2178_ VGND VGND VPWR VPWR _2945_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9005_ clknet_leaf_11_CLK _0165_ VGND VGND VPWR VPWR regfile.registers\[29\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_6148_ _1731_ _2853_ _2838_ VGND VGND VPWR VPWR _2880_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6079_ _2667_ _2745_ VGND VGND VPWR VPWR _2815_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_121_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5450_ regfile.registers\[4\]\[10\] regfile.registers\[5\]\[10\] regfile.registers\[6\]\[10\]
+ regfile.registers\[7\]\[10\] _1718_ _1721_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4401_ _1038_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__nand2_1
XFILLER_0_112_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5381_ regfile.registers\[0\]\[14\] regfile.registers\[1\]\[14\] regfile.registers\[2\]\[14\]
+ regfile.registers\[3\]\[14\] _2117_ _2118_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__mux4_1
X_7120_ _3487_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
X_4332_ _1050_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__buf_4
XFILLER_0_22_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7051_ _3448_ VGND VGND VPWR VPWR _3449_ sky130_fd_sc_hd__clkbuf_8
X_6002_ _1512_ _2658_ _2741_ VGND VGND VPWR VPWR _2742_ sky130_fd_sc_hd__a21oi_1
X_7953_ _3143_ net767 _3938_ VGND VGND VPWR VPWR _3943_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6904_ _3370_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__clkbuf_1
X_7884_ _3906_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6835_ _3333_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6766_ net524 _3009_ _3289_ VGND VGND VPWR VPWR _3297_ sky130_fd_sc_hd__mux2_1
X_9554_ clknet_leaf_45_CLK _0714_ VGND VGND VPWR VPWR regfile.registers\[11\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5717_ _2396_ _2400_ _1877_ VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__mux2_1
X_8505_ _4235_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_98_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6697_ _3260_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__clkbuf_1
X_9485_ clknet_leaf_94_CLK _0645_ VGND VGND VPWR VPWR regfile.registers\[16\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_103_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8436_ net551 net35 _4191_ VGND VGND VPWR VPWR _4199_ sky130_fd_sc_hd__mux2_1
X_5648_ _2400_ _2402_ _1145_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8367_ _4162_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__clkbuf_1
X_5579_ _1128_ _1663_ _2330_ _2334_ VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__o211ai_2
XFILLER_0_103_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold240 regfile.registers\[0\]\[28\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
X_8298_ _3002_ net906 _4119_ VGND VGND VPWR VPWR _4126_ sky130_fd_sc_hd__mux2_1
X_7318_ _3606_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
Xhold251 regfile.registers\[6\]\[5\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
Xhold262 regfile.registers\[3\]\[0\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 regfile.registers\[25\]\[8\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold284 regfile.registers\[20\]\[12\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
X_7249_ net673 _3521_ _3564_ VGND VGND VPWR VPWR _3569_ sky130_fd_sc_hd__mux2_1
Xhold295 regfile.registers\[0\]\[12\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_107_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput8 A2[4] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_4
XFILLER_0_36_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4950_ _1678_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__buf_4
X_4881_ _1350_ _1385_ _1448_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__or4b_4
XFILLER_0_59_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6620_ _3219_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6551_ _3181_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5502_ _2256_ _2257_ _2044_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__mux2_1
X_6482_ net225 _3143_ _3135_ VGND VGND VPWR VPWR _3144_ sky130_fd_sc_hd__mux2_1
X_9270_ clknet_leaf_52_CLK _0430_ VGND VGND VPWR VPWR regfile.registers\[18\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8221_ _4085_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5433_ regfile.registers\[4\]\[11\] regfile.registers\[5\]\[11\] regfile.registers\[6\]\[11\]
+ regfile.registers\[7\]\[11\] _1703_ _1706_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__mux4_1
X_8152_ net505 _3536_ _4047_ VGND VGND VPWR VPWR _4049_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_93_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5364_ regfile.registers\[0\]\[15\] regfile.registers\[1\]\[15\] regfile.registers\[2\]\[15\]
+ regfile.registers\[3\]\[15\] _2117_ _2118_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__mux4_1
X_7103_ _3476_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4315_ _1037_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__clkbuf_8
X_8083_ _4012_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__clkbuf_1
X_5295_ _2050_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__buf_4
X_7034_ _3439_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8985_ clknet_leaf_50_CLK _0145_ VGND VGND VPWR VPWR regfile.registers\[7\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_7936_ _3126_ net854 _3927_ VGND VGND VPWR VPWR _3934_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7867_ _3897_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6818_ _3324_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_102_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7798_ net229 _3523_ _3855_ VGND VGND VPWR VPWR _3861_ sky130_fd_sc_hd__mux2_1
XFILLER_0_123_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6749_ net325 _3132_ _3278_ VGND VGND VPWR VPWR _3288_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9537_ clknet_leaf_90_CLK _0697_ VGND VGND VPWR VPWR regfile.registers\[11\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9468_ clknet_leaf_15_CLK _0628_ VGND VGND VPWR VPWR regfile.registers\[13\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_21_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8419_ net335 _3531_ _4180_ VGND VGND VPWR VPWR _4190_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9399_ clknet_leaf_35_CLK _0559_ VGND VGND VPWR VPWR regfile.registers\[24\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkbuf_3_1__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_1__leaf_CLK sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5080_ _1834_ _1835_ _1686_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5982_ _1495_ net105 _2536_ VGND VGND VPWR VPWR _2723_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_63_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8770_ clknet_leaf_86_CLK _0954_ VGND VGND VPWR VPWR regfile.registers\[14\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4933_ _1675_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__clkbuf_8
X_7721_ _3820_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_740 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7652_ net347 _3512_ _3783_ VGND VGND VPWR VPWR _3784_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4864_ regfile.registers\[16\]\[18\] regfile.registers\[17\]\[18\] regfile.registers\[18\]\[18\]
+ regfile.registers\[19\]\[18\] net1141 _1202_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__mux4_1
X_7583_ _3735_ VGND VGND VPWR VPWR _3747_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4795_ regfile.registers\[12\]\[10\] regfile.registers\[13\]\[10\] regfile.registers\[14\]\[10\]
+ regfile.registers\[15\]\[10\] _1052_ _1090_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__mux4_1
X_6603_ _3210_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__clkbuf_1
X_6534_ _3172_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__clkbuf_1
X_9322_ clknet_leaf_107_CLK _0482_ VGND VGND VPWR VPWR regfile.registers\[21\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6465_ net26 VGND VGND VPWR VPWR _3132_ sky130_fd_sc_hd__buf_2
X_9253_ clknet_leaf_63_CLK _0413_ VGND VGND VPWR VPWR regfile.registers\[18\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5416_ regfile.registers\[0\]\[12\] regfile.registers\[1\]\[12\] regfile.registers\[2\]\[12\]
+ regfile.registers\[3\]\[12\] _1718_ _1721_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__mux4_1
X_8204_ _4076_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6396_ _3084_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9184_ clknet_leaf_78_CLK _0344_ VGND VGND VPWR VPWR regfile.registers\[30\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_5347_ _1127_ _1663_ _2100_ _2102_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__a31o_1
X_8135_ net653 _3519_ _4036_ VGND VGND VPWR VPWR _4040_ sky130_fd_sc_hd__mux2_1
X_5278_ _1639_ _2033_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__or2_1
X_8066_ _4003_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__clkbuf_1
X_7017_ _3430_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
X_8968_ clknet_leaf_96_CLK _0128_ VGND VGND VPWR VPWR regfile.registers\[7\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_7919_ _3109_ net353 _3916_ VGND VGND VPWR VPWR _3925_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_26_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8899_ clknet_leaf_83_CLK _0059_ VGND VGND VPWR VPWR regfile.registers\[19\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_643 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4580_ regfile.registers\[28\]\[30\] regfile.registers\[29\]\[30\] regfile.registers\[30\]\[30\]
+ regfile.registers\[31\]\[30\] _1201_ _1203_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__mux4_1
Xinput11 A3[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput22 WD3[15] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_37_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput33 WD3[25] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
XFILLER_0_109_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput44 WD3[6] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold817 regfile.registers\[22\]\[29\] VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__dlygate4sd3_1
Xhold806 regfile.registers\[30\]\[26\] VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold828 regfile.registers\[27\]\[15\] VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__dlygate4sd3_1
X_6250_ _2178_ _1980_ _1960_ _1127_ VGND VGND VPWR VPWR _2976_ sky130_fd_sc_hd__o31a_1
Xhold839 regfile.registers\[23\]\[16\] VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6181_ _2254_ _2848_ _2910_ _2336_ VGND VGND VPWR VPWR _2911_ sky130_fd_sc_hd__o22a_1
X_5201_ _1951_ _1953_ _1956_ _1773_ _1672_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_90_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5132_ regfile.registers\[20\]\[31\] regfile.registers\[21\]\[31\] regfile.registers\[22\]\[31\]
+ regfile.registers\[23\]\[31\] _1882_ _1884_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__mux4_1
X_5063_ _1717_ _1818_ _1729_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__a21oi_1
X_8822_ clknet_leaf_50_CLK _1006_ VGND VGND VPWR VPWR regfile.registers\[6\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_88_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5965_ _1087_ _2706_ VGND VGND VPWR VPWR _2707_ sky130_fd_sc_hd__and2_1
X_8753_ clknet_leaf_18_CLK _0937_ VGND VGND VPWR VPWR regfile.registers\[8\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4916_ _1671_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__buf_4
X_5896_ _2595_ _2639_ _1572_ VGND VGND VPWR VPWR _2641_ sky130_fd_sc_hd__a21o_1
X_7704_ _3811_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__clkbuf_1
X_8684_ clknet_leaf_8_CLK _0868_ VGND VGND VPWR VPWR regfile.registers\[0\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4847_ regfile.registers\[20\]\[19\] regfile.registers\[21\]\[19\] regfile.registers\[22\]\[19\]
+ regfile.registers\[23\]\[19\] _1182_ _1184_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7635_ net520 _3496_ _3772_ VGND VGND VPWR VPWR _3775_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9305_ clknet_leaf_39_CLK _0465_ VGND VGND VPWR VPWR regfile.registers\[25\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_4778_ regfile.registers\[8\]\[9\] regfile.registers\[9\]\[9\] regfile.registers\[10\]\[9\]
+ regfile.registers\[11\]\[9\] _1104_ _1105_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__mux4_1
X_7566_ _3738_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6517_ _3163_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__clkbuf_1
X_7497_ _3025_ net1069 _3700_ VGND VGND VPWR VPWR _3702_ sky130_fd_sc_hd__mux2_1
X_9236_ clknet_leaf_15_CLK _0396_ VGND VGND VPWR VPWR regfile.registers\[9\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_6448_ net209 _3120_ _3114_ VGND VGND VPWR VPWR _3121_ sky130_fd_sc_hd__mux2_1
X_6379_ net32 VGND VGND VPWR VPWR _3073_ sky130_fd_sc_hd__buf_2
XFILLER_0_100_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9167_ clknet_leaf_1_CLK _0327_ VGND VGND VPWR VPWR regfile.registers\[2\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8118_ net326 _3502_ _4025_ VGND VGND VPWR VPWR _4031_ sky130_fd_sc_hd__mux2_1
X_9098_ clknet_leaf_108_CLK _0258_ VGND VGND VPWR VPWR regfile.registers\[27\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_110_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8049_ _3994_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_707 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5750_ _2497_ _2500_ _2501_ VGND VGND VPWR VPWR _2502_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5681_ _2255_ _2431_ _2434_ _2373_ VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__o211a_1
X_4701_ _1198_ _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__or2_1
XFILLER_0_127_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7420_ _3085_ net740 _3626_ VGND VGND VPWR VPWR _3660_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4632_ regfile.registers\[16\]\[6\] regfile.registers\[17\]\[6\] regfile.registers\[18\]\[6\]
+ regfile.registers\[19\]\[6\] _1219_ _1221_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__mux4_2
XFILLER_0_127_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold603 regfile.registers\[26\]\[25\] VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlygate4sd3_1
X_7351_ _3623_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4563_ _1317_ _1318_ _1198_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__mux2_1
Xhold625 regfile.registers\[13\]\[23\] VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dlygate4sd3_1
X_4494_ _1199_ _1249_ _1213_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__o21a_1
Xhold614 regfile.registers\[15\]\[30\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__dlygate4sd3_1
X_7282_ net136 _3486_ _3552_ VGND VGND VPWR VPWR _3586_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6302_ net12 net11 net13 VGND VGND VPWR VPWR _3020_ sky130_fd_sc_hd__and3b_4
Xhold636 regfile.registers\[21\]\[18\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlygate4sd3_1
Xhold647 regfile.registers\[20\]\[25\] VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlygate4sd3_1
X_6233_ _1148_ _2958_ _2959_ _2337_ VGND VGND VPWR VPWR _2960_ sky130_fd_sc_hd__a211o_1
XFILLER_0_110_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold669 regfile.registers\[30\]\[30\] VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlygate4sd3_1
Xhold658 regfile.registers\[22\]\[31\] VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlygate4sd3_1
X_9021_ clknet_leaf_11_CLK _0181_ VGND VGND VPWR VPWR regfile.registers\[29\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6164_ _2386_ _2391_ VGND VGND VPWR VPWR _2895_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6095_ _1779_ _2829_ VGND VGND VPWR VPWR _2830_ sky130_fd_sc_hd__xor2_1
X_5115_ regfile.registers\[0\]\[16\] regfile.registers\[1\]\[16\] regfile.registers\[2\]\[16\]
+ regfile.registers\[3\]\[16\] _1822_ _1823_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__mux4_1
X_5046_ _1781_ _1801_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8805_ clknet_leaf_61_CLK _0989_ VGND VGND VPWR VPWR regfile.registers\[6\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_6997_ net687 _3107_ _3412_ VGND VGND VPWR VPWR _3420_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5948_ _2661_ _2669_ net110 VGND VGND VPWR VPWR _2691_ sky130_fd_sc_hd__a21boi_1
X_8736_ clknet_leaf_76_CLK _0920_ VGND VGND VPWR VPWR regfile.registers\[8\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_8667_ clknet_leaf_26_CLK _0851_ VGND VGND VPWR VPWR regfile.registers\[22\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_5879_ _2548_ _2624_ _2426_ VGND VGND VPWR VPWR _2625_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8598_ clknet_leaf_52_CLK _0782_ VGND VGND VPWR VPWR regfile.registers\[23\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7618_ _3765_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7549_ _3077_ net914 _3722_ VGND VGND VPWR VPWR _3729_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9219_ clknet_leaf_89_CLK _0379_ VGND VGND VPWR VPWR regfile.registers\[9\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6920_ _3379_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__clkbuf_1
X_6851_ net291 _3097_ _3340_ VGND VGND VPWR VPWR _3343_ sky130_fd_sc_hd__mux2_1
X_5802_ _2530_ _2550_ _2551_ _2373_ VGND VGND VPWR VPWR _2552_ sky130_fd_sc_hd__o211a_1
X_9570_ clknet_leaf_87_CLK _0730_ VGND VGND VPWR VPWR regfile.registers\[10\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6782_ _3027_ net940 _3303_ VGND VGND VPWR VPWR _3306_ sky130_fd_sc_hd__mux2_1
X_8521_ _4243_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_33_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5733_ _2459_ _2467_ _2477_ _2485_ _2408_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__o32a_1
XFILLER_0_17_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5664_ _2082_ _2099_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__nand2_1
X_8452_ net543 net38 _4205_ VGND VGND VPWR VPWR _4208_ sky130_fd_sc_hd__mux2_1
X_4615_ regfile.registers\[24\]\[24\] regfile.registers\[25\]\[24\] regfile.registers\[26\]\[24\]
+ regfile.registers\[27\]\[24\] _1360_ _1361_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__mux4_1
X_7403_ _3651_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
X_5595_ _1668_ _2194_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8383_ _4171_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7334_ _3067_ net649 _3613_ VGND VGND VPWR VPWR _3615_ sky130_fd_sc_hd__mux2_1
X_4546_ _1300_ _1301_ _1259_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__mux2_1
Xhold400 regfile.registers\[0\]\[26\] VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold411 regfile.registers\[24\]\[14\] VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlygate4sd3_1
Xhold444 regfile.registers\[8\]\[27\] VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold422 regfile.registers\[22\]\[7\] VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold433 regfile.registers\[6\]\[13\] VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__dlygate4sd3_1
X_7265_ _3577_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_4477_ regfile.registers\[8\]\[28\] regfile.registers\[9\]\[28\] regfile.registers\[10\]\[28\]
+ regfile.registers\[11\]\[28\] _1182_ _1184_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__mux4_1
Xhold466 regfile.registers\[30\]\[19\] VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__dlygate4sd3_1
Xhold477 regfile.registers\[19\]\[15\] VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__dlygate4sd3_1
Xhold455 regfile.registers\[10\]\[2\] VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__dlygate4sd3_1
X_6216_ _1980_ _1960_ VGND VGND VPWR VPWR _2944_ sky130_fd_sc_hd__nor2_1
X_7196_ _3539_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
X_9004_ clknet_leaf_109_CLK _0164_ VGND VGND VPWR VPWR regfile.registers\[29\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold488 regfile.registers\[25\]\[4\] VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__dlygate4sd3_1
Xhold499 regfile.registers\[31\]\[4\] VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__dlygate4sd3_1
X_6147_ _2814_ _2815_ _2748_ _2816_ _2878_ VGND VGND VPWR VPWR _2879_ sky130_fd_sc_hd__a311o_1
X_6078_ _2813_ _2665_ _2745_ _2600_ VGND VGND VPWR VPWR _2814_ sky130_fd_sc_hd__or4b_4
X_5029_ _1783_ _1784_ _1739_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__mux2_1
XFILLER_0_95_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8719_ clknet_leaf_3_CLK _0903_ VGND VGND VPWR VPWR regfile.registers\[15\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_749 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4400_ _1154_ _1155_ _1107_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5380_ regfile.registers\[4\]\[14\] regfile.registers\[5\]\[14\] regfile.registers\[6\]\[14\]
+ regfile.registers\[7\]\[14\] _2117_ _2118_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__mux4_1
X_4331_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__buf_2
XFILLER_0_120_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7050_ _3447_ _3090_ VGND VGND VPWR VPWR _3448_ sky130_fd_sc_hd__nor2_2
XFILLER_0_10_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6001_ _2536_ VGND VGND VPWR VPWR _2741_ sky130_fd_sc_hd__buf_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7952_ _3942_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__clkbuf_1
X_6903_ net247 _3009_ _3362_ VGND VGND VPWR VPWR _3370_ sky130_fd_sc_hd__mux2_1
X_7883_ net245 _3540_ _3902_ VGND VGND VPWR VPWR _3906_ sky130_fd_sc_hd__mux2_1
XFILLER_0_106_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6834_ _3079_ net1108 _3325_ VGND VGND VPWR VPWR _3333_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6765_ _3296_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__clkbuf_1
X_9553_ clknet_leaf_19_CLK _0713_ VGND VGND VPWR VPWR regfile.registers\[11\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_59_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5716_ _2387_ _2393_ _1146_ VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__mux2_1
X_8504_ net1024 net35 _4227_ VGND VGND VPWR VPWR _4235_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9484_ clknet_leaf_111_CLK _0644_ VGND VGND VPWR VPWR regfile.registers\[16\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_6696_ _3077_ net1080 _3253_ VGND VGND VPWR VPWR _3260_ sky130_fd_sc_hd__mux2_1
X_8435_ _4198_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5647_ _1168_ _1821_ _2401_ VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8366_ net747 _3478_ _4155_ VGND VGND VPWR VPWR _4162_ sky130_fd_sc_hd__mux2_1
X_5578_ _2331_ _2332_ _2333_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__a21o_1
X_8297_ _4125_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__clkbuf_1
Xhold241 regfile.registers\[12\]\[28\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold252 regfile.registers\[12\]\[22\] VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold230 regfile.registers\[24\]\[30\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
X_4529_ _1283_ _1284_ _1198_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__mux2_1
X_7317_ _3050_ net804 _3602_ VGND VGND VPWR VPWR _3606_ sky130_fd_sc_hd__mux2_1
Xhold274 regfile.registers\[2\]\[27\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 regfile.registers\[19\]\[30\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_68_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold296 regfile.registers\[24\]\[19\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 regfile.registers\[11\]\[12\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
X_7248_ _3568_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
X_7179_ net390 _3527_ _3513_ VGND VGND VPWR VPWR _3528_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput9 A3[0] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4880_ _1512_ net101 _1635_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6550_ _3071_ net909 _3177_ VGND VGND VPWR VPWR _3181_ sky130_fd_sc_hd__mux2_1
XFILLER_0_117_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5501_ regfile.registers\[16\]\[6\] regfile.registers\[17\]\[6\] regfile.registers\[18\]\[6\]
+ regfile.registers\[19\]\[6\] _1733_ _1679_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__mux4_1
XFILLER_0_125_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6481_ net32 VGND VGND VPWR VPWR _3143_ sky130_fd_sc_hd__buf_2
X_8220_ net249 _3536_ _4083_ VGND VGND VPWR VPWR _4085_ sky130_fd_sc_hd__mux2_1
X_5432_ _1686_ _2185_ _2187_ _1699_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_93_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8151_ _4048_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__clkbuf_1
X_5363_ regfile.registers\[4\]\[15\] regfile.registers\[5\]\[15\] regfile.registers\[6\]\[15\]
+ regfile.registers\[7\]\[15\] _2117_ _2118_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__mux4_1
X_7102_ net495 _3143_ _3471_ VGND VGND VPWR VPWR _3476_ sky130_fd_sc_hd__mux2_1
X_4314_ _1064_ _1069_ _1037_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__mux2_1
X_8082_ net493 _3533_ _4011_ VGND VGND VPWR VPWR _4012_ sky130_fd_sc_hd__mux2_1
X_5294_ _1673_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__buf_4
X_7033_ net344 _3143_ _3434_ VGND VGND VPWR VPWR _3439_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8984_ clknet_leaf_17_CLK _0144_ VGND VGND VPWR VPWR regfile.registers\[7\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_96_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7935_ _3933_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__clkbuf_1
X_7866_ net539 _3523_ _3891_ VGND VGND VPWR VPWR _3897_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6817_ _3062_ net1052 _3314_ VGND VGND VPWR VPWR _3324_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_102_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9536_ clknet_leaf_76_CLK _0696_ VGND VGND VPWR VPWR regfile.registers\[11\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_7797_ _3860_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__clkbuf_1
X_6748_ _3287_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9467_ clknet_leaf_39_CLK _0627_ VGND VGND VPWR VPWR regfile.registers\[13\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6679_ _3060_ net571 _3242_ VGND VGND VPWR VPWR _3251_ sky130_fd_sc_hd__mux2_1
X_9398_ clknet_leaf_52_CLK _0558_ VGND VGND VPWR VPWR regfile.registers\[24\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8418_ _4189_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_76_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8349_ net498 _3529_ _4144_ VGND VGND VPWR VPWR _4153_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_94_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5981_ _2571_ _2605_ _2720_ _1087_ _2721_ VGND VGND VPWR VPWR _2722_ sky130_fd_sc_hd__a221o_1
X_4932_ regfile.registers\[28\]\[23\] regfile.registers\[29\]\[23\] regfile.registers\[30\]\[23\]
+ regfile.registers\[31\]\[23\] _1676_ _1681_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__mux4_1
X_7720_ _3043_ net985 _3819_ VGND VGND VPWR VPWR _3820_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7651_ _3771_ VGND VGND VPWR VPWR _3783_ sky130_fd_sc_hd__buf_4
XFILLER_0_28_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6602_ net475 _3122_ _3205_ VGND VGND VPWR VPWR _3210_ sky130_fd_sc_hd__mux2_1
X_4863_ regfile.registers\[20\]\[18\] regfile.registers\[21\]\[18\] regfile.registers\[22\]\[18\]
+ regfile.registers\[23\]\[18\] net1141 _1202_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__mux4_1
X_7582_ _3746_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4794_ regfile.registers\[8\]\[10\] regfile.registers\[9\]\[10\] regfile.registers\[10\]\[10\]
+ regfile.registers\[11\]\[10\] net98 _1053_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__mux4_1
X_6533_ _3054_ net533 _3166_ VGND VGND VPWR VPWR _3172_ sky130_fd_sc_hd__mux2_1
X_9321_ clknet_leaf_105_CLK _0481_ VGND VGND VPWR VPWR regfile.registers\[21\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_125_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9252_ clknet_leaf_92_CLK _0412_ VGND VGND VPWR VPWR regfile.registers\[18\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_6464_ _3131_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5415_ regfile.registers\[4\]\[12\] regfile.registers\[5\]\[12\] regfile.registers\[6\]\[12\]
+ regfile.registers\[7\]\[12\] _1718_ _1721_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__mux4_1
X_8203_ net595 _3519_ _4072_ VGND VGND VPWR VPWR _4076_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6395_ _3083_ net856 _3065_ VGND VGND VPWR VPWR _3084_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9183_ clknet_leaf_79_CLK _0343_ VGND VGND VPWR VPWR regfile.registers\[30\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_112_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5346_ _1060_ _2101_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__nand2_4
X_8134_ _4039_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__clkbuf_1
X_5277_ _1777_ _2024_ _2032_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__a21oi_2
X_8065_ net364 _3517_ _4000_ VGND VGND VPWR VPWR _4003_ sky130_fd_sc_hd__mux2_1
X_7016_ net698 _3126_ _3423_ VGND VGND VPWR VPWR _3430_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8967_ clknet_leaf_67_CLK _0127_ VGND VGND VPWR VPWR regfile.registers\[7\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7918_ _3924_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__clkbuf_1
X_8898_ clknet_leaf_86_CLK _0058_ VGND VGND VPWR VPWR regfile.registers\[19\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7849_ net476 _3506_ _3880_ VGND VGND VPWR VPWR _3888_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9519_ clknet_leaf_3_CLK _0679_ VGND VGND VPWR VPWR regfile.registers\[12\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput12 A3[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_2
Xinput34 WD3[26] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_77_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 WD3[16] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
XFILLER_0_24_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput45 WD3[7] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_2
Xhold818 regfile.registers\[14\]\[25\] VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__dlygate4sd3_1
Xhold807 regfile.registers\[5\]\[22\] VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_77_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold829 regfile.registers\[22\]\[23\] VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6180_ _2866_ _2909_ _2327_ VGND VGND VPWR VPWR _2910_ sky130_fd_sc_hd__mux2_1
X_5200_ _1954_ _1955_ _1889_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__mux2_1
X_5131_ regfile.registers\[16\]\[31\] regfile.registers\[17\]\[31\] regfile.registers\[18\]\[31\]
+ regfile.registers\[19\]\[31\] _1882_ _1884_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__mux4_1
X_5062_ _1816_ _1817_ _1686_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__mux2_1
X_8821_ clknet_leaf_31_CLK _1005_ VGND VGND VPWR VPWR regfile.registers\[6\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_88_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8752_ clknet_leaf_10_CLK _0936_ VGND VGND VPWR VPWR regfile.registers\[8\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_5964_ _2549_ _2705_ _2104_ VGND VGND VPWR VPWR _2706_ sky130_fd_sc_hd__mux2_1
X_7703_ _3027_ net950 _3808_ VGND VGND VPWR VPWR _3811_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5895_ _1572_ _2595_ _2639_ VGND VGND VPWR VPWR _2640_ sky130_fd_sc_hd__nand3_1
X_8683_ clknet_leaf_97_CLK _0867_ VGND VGND VPWR VPWR regfile.registers\[0\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_4915_ _1670_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_118_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4846_ _1587_ _1601_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7634_ _3774_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7565_ _3025_ net564 _3736_ VGND VGND VPWR VPWR _3738_ sky130_fd_sc_hd__mux2_1
X_9304_ clknet_leaf_21_CLK _0464_ VGND VGND VPWR VPWR regfile.registers\[25\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_4777_ _1529_ _1530_ _1531_ _1532_ _1040_ _1038_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__mux4_2
X_6516_ _3037_ net502 _3155_ VGND VGND VPWR VPWR _3163_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7496_ _3701_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
X_9235_ clknet_leaf_33_CLK _0395_ VGND VGND VPWR VPWR regfile.registers\[9\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_6447_ net20 VGND VGND VPWR VPWR _3120_ sky130_fd_sc_hd__buf_2
X_6378_ _3072_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__clkbuf_1
X_9166_ clknet_leaf_5_CLK _0326_ VGND VGND VPWR VPWR regfile.registers\[2\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5329_ regfile.registers\[28\]\[1\] regfile.registers\[29\]\[1\] regfile.registers\[30\]\[1\]
+ regfile.registers\[31\]\[1\] _1701_ _1677_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__mux4_1
X_8117_ _4030_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_110_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9097_ clknet_leaf_101_CLK _0257_ VGND VGND VPWR VPWR regfile.registers\[27\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_110_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8048_ net488 _3500_ _3989_ VGND VGND VPWR VPWR _3994_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_3_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_123_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_736 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5680_ _1148_ _2432_ _2433_ _2337_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4700_ regfile.registers\[4\]\[12\] regfile.registers\[5\]\[12\] regfile.registers\[6\]\[12\]
+ regfile.registers\[7\]\[12\] _1172_ _1279_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__mux4_1
XFILLER_0_121_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4631_ regfile.registers\[28\]\[6\] regfile.registers\[29\]\[6\] regfile.registers\[30\]\[6\]
+ regfile.registers\[31\]\[6\] _1219_ _1221_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__mux4_1
XFILLER_0_115_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7350_ _3083_ net1015 _3613_ VGND VGND VPWR VPWR _3623_ sky130_fd_sc_hd__mux2_1
X_4562_ regfile.registers\[16\]\[31\] regfile.registers\[17\]\[31\] regfile.registers\[18\]\[31\]
+ regfile.registers\[19\]\[31\] _1200_ _1202_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold615 regfile.registers\[28\]\[25\] VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dlygate4sd3_1
X_7281_ _3585_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
X_4493_ regfile.registers\[12\]\[20\] regfile.registers\[13\]\[20\] regfile.registers\[14\]\[20\]
+ regfile.registers\[15\]\[20\] _1201_ _1203_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__mux4_1
Xhold604 regfile.registers\[20\]\[13\] VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__dlygate4sd3_1
X_6301_ net16 VGND VGND VPWR VPWR _3019_ sky130_fd_sc_hd__clkbuf_2
Xhold626 regfile.registers\[14\]\[7\] VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlygate4sd3_1
Xhold637 regfile.registers\[28\]\[24\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_122_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6232_ _2923_ _2384_ _1148_ VGND VGND VPWR VPWR _2959_ sky130_fd_sc_hd__a21oi_1
X_9020_ clknet_leaf_41_CLK _0180_ VGND VGND VPWR VPWR regfile.registers\[29\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold659 regfile.registers\[23\]\[19\] VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold648 regfile.registers\[12\]\[12\] VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6163_ _2887_ _2893_ VGND VGND VPWR VPWR _2894_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6094_ _1277_ _2828_ VGND VGND VPWR VPWR _2829_ sky130_fd_sc_hd__xnor2_1
X_5114_ regfile.registers\[4\]\[16\] regfile.registers\[5\]\[16\] regfile.registers\[6\]\[16\]
+ regfile.registers\[7\]\[16\] _1822_ _1823_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__mux4_1
XFILLER_0_109_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5045_ _1758_ _1798_ _1800_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8804_ clknet_leaf_91_CLK _0988_ VGND VGND VPWR VPWR regfile.registers\[6\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_6996_ _3419_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_125_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5947_ net110 _2669_ _2661_ VGND VGND VPWR VPWR _2690_ sky130_fd_sc_hd__and3b_1
XFILLER_0_75_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8735_ clknet_leaf_81_CLK _0919_ VGND VGND VPWR VPWR regfile.registers\[8\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8666_ clknet_leaf_25_CLK _0850_ VGND VGND VPWR VPWR regfile.registers\[22\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5878_ _2623_ VGND VGND VPWR VPWR _2624_ sky130_fd_sc_hd__inv_2
X_7617_ _3077_ net319 _3758_ VGND VGND VPWR VPWR _3765_ sky130_fd_sc_hd__mux2_1
Xclone15 _1089_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8597_ clknet_leaf_29_CLK _0781_ VGND VGND VPWR VPWR regfile.registers\[23\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4829_ _1583_ _1584_ _1036_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__mux2_1
X_7548_ _3728_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7479_ _3075_ net683 _3686_ VGND VGND VPWR VPWR _3692_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9218_ clknet_leaf_88_CLK _0378_ VGND VGND VPWR VPWR regfile.registers\[9\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9149_ clknet_leaf_11_CLK _0309_ VGND VGND VPWR VPWR regfile.registers\[28\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_123_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6850_ _3342_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__clkbuf_1
X_5801_ _2254_ _2425_ _2431_ _2337_ VGND VGND VPWR VPWR _2551_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6781_ _3305_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5732_ _2482_ _2484_ VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__xnor2_1
X_8520_ net184 net41 _3007_ VGND VGND VPWR VPWR _4243_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5663_ _1662_ VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__inv_2
X_8451_ _4207_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7402_ _3067_ net1079 _3649_ VGND VGND VPWR VPWR _3651_ sky130_fd_sc_hd__mux2_1
X_4614_ _1171_ _1359_ _1365_ _1369_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_103_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5594_ _1758_ _2175_ _1839_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__o21ai_1
X_8382_ net1035 _3494_ _4169_ VGND VGND VPWR VPWR _4171_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4545_ regfile.registers\[16\]\[27\] regfile.registers\[17\]\[27\] regfile.registers\[18\]\[27\]
+ regfile.registers\[19\]\[27\] _1262_ _1263_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__mux4_1
XFILLER_0_102_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7333_ _3614_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
Xhold401 regfile.registers\[18\]\[22\] VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold445 regfile.registers\[27\]\[27\] VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold412 regfile.registers\[19\]\[22\] VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__dlygate4sd3_1
Xhold434 regfile.registers\[9\]\[14\] VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlygate4sd3_1
Xhold423 regfile.registers\[18\]\[6\] VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__dlygate4sd3_1
X_7264_ net713 _3536_ _3575_ VGND VGND VPWR VPWR _3577_ sky130_fd_sc_hd__mux2_1
XFILLER_0_111_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold456 regfile.registers\[8\]\[28\] VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__dlygate4sd3_1
X_4476_ _1199_ _1231_ _1213_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__a21o_1
Xhold478 regfile.registers\[5\]\[30\] VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd3_1
Xhold467 regfile.registers\[31\]\[31\] VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__dlygate4sd3_1
X_9003_ clknet_leaf_103_CLK _0163_ VGND VGND VPWR VPWR regfile.registers\[29\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_6215_ _1962_ _2942_ _2421_ VGND VGND VPWR VPWR _2943_ sky130_fd_sc_hd__o21ai_1
X_7195_ net1081 _3538_ _3534_ VGND VGND VPWR VPWR _3539_ sky130_fd_sc_hd__mux2_1
Xhold489 regfile.registers\[29\]\[15\] VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6146_ _2808_ _2830_ _2840_ _2854_ VGND VGND VPWR VPWR _2878_ sky130_fd_sc_hd__or4_1
X_6077_ _2601_ VGND VGND VPWR VPWR _2813_ sky130_fd_sc_hd__inv_2
X_5028_ regfile.registers\[16\]\[20\] regfile.registers\[17\]\[20\] regfile.registers\[18\]\[20\]
+ regfile.registers\[19\]\[20\] _1782_ _1680_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_105_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6979_ net1064 _3017_ _3375_ VGND VGND VPWR VPWR _3410_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8718_ clknet_leaf_20_CLK _0902_ VGND VGND VPWR VPWR regfile.registers\[15\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8649_ clknet_leaf_103_CLK _0833_ VGND VGND VPWR VPWR regfile.registers\[22\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold990 regfile.registers\[26\]\[10\] VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_19_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4330_ _1060_ _1085_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6000_ _2584_ _2731_ _2736_ _2496_ _2739_ VGND VGND VPWR VPWR _2740_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_105_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7951_ _3141_ net455 _3938_ VGND VGND VPWR VPWR _3942_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7882_ _3905_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6902_ _3369_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__clkbuf_1
X_6833_ _3332_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_114_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6764_ net521 _3002_ _3289_ VGND VGND VPWR VPWR _3296_ sky130_fd_sc_hd__mux2_1
X_9552_ clknet_leaf_6_CLK _0712_ VGND VGND VPWR VPWR regfile.registers\[11\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_6695_ _3259_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__clkbuf_1
X_5715_ _1666_ VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_98_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8503_ _4234_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9483_ clknet_leaf_105_CLK _0643_ VGND VGND VPWR VPWR regfile.registers\[16\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_128_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5646_ _1667_ _1859_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8434_ net324 net34 _4191_ VGND VGND VPWR VPWR _4198_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8365_ _4161_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__clkbuf_1
Xhold220 regfile.registers\[3\]\[28\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
X_5577_ net15 VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__buf_2
X_8296_ _3145_ net666 _4119_ VGND VGND VPWR VPWR _4125_ sky130_fd_sc_hd__mux2_1
Xhold231 regfile.registers\[2\]\[21\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
X_4528_ regfile.registers\[24\]\[26\] regfile.registers\[25\]\[26\] regfile.registers\[26\]\[26\]
+ regfile.registers\[27\]\[26\] _1181_ _1183_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__mux4_1
X_7316_ _3605_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
Xhold253 regfile.registers\[16\]\[10\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold242 regfile.registers\[2\]\[5\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold264 regfile.registers\[4\]\[24\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4459_ _1025_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__buf_4
Xhold286 regfile.registers\[11\]\[3\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 regfile.registers\[5\]\[5\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
X_7247_ net340 _3519_ _3564_ VGND VGND VPWR VPWR _3568_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_123_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold297 regfile.registers\[9\]\[29\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
X_7178_ net24 VGND VGND VPWR VPWR _3527_ sky130_fd_sc_hd__buf_2
X_6129_ _2496_ _2859_ _2861_ _2504_ VGND VGND VPWR VPWR _2862_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_107_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5500_ regfile.registers\[20\]\[6\] regfile.registers\[21\]\[6\] regfile.registers\[22\]\[6\]
+ regfile.registers\[23\]\[6\] _1733_ _1679_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__mux4_1
X_6480_ _3142_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5431_ _1711_ _2186_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_93_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8150_ net562 _3533_ _4047_ VGND VGND VPWR VPWR _4048_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_60_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_60_CLK sky130_fd_sc_hd__clkbuf_8
X_5362_ _1678_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__buf_4
X_7101_ _3475_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
X_8081_ _3988_ VGND VGND VPWR VPWR _4011_ sky130_fd_sc_hd__clkbuf_8
X_4313_ _1067_ _1068_ _1035_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__mux2_1
X_7032_ _3438_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_5293_ _2045_ _2048_ _1696_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__mux2_1
X_8983_ clknet_leaf_50_CLK _0143_ VGND VGND VPWR VPWR regfile.registers\[7\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7934_ _3124_ net723 _3927_ VGND VGND VPWR VPWR _3933_ sky130_fd_sc_hd__mux2_1
X_7865_ _3896_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7796_ net514 _3521_ _3855_ VGND VGND VPWR VPWR _3860_ sky130_fd_sc_hd__mux2_1
X_6816_ _3323_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6747_ net611 _3130_ _3278_ VGND VGND VPWR VPWR _3287_ sky130_fd_sc_hd__mux2_1
X_9535_ clknet_leaf_81_CLK _0695_ VGND VGND VPWR VPWR regfile.registers\[11\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_9466_ clknet_leaf_16_CLK _0626_ VGND VGND VPWR VPWR regfile.registers\[13\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6678_ _3250_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__clkbuf_1
X_9397_ clknet_leaf_30_CLK _0557_ VGND VGND VPWR VPWR regfile.registers\[24\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_5629_ _1799_ _1979_ VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8417_ net565 _3529_ _4180_ VGND VGND VPWR VPWR _4189_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_51_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_51_CLK sky130_fd_sc_hd__clkbuf_8
X_8348_ _4152_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__clkbuf_1
X_8279_ _3128_ net613 _4108_ VGND VGND VPWR VPWR _4116_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_42_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_42_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_122_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5980_ _2468_ _2530_ _2426_ _2472_ _2503_ VGND VGND VPWR VPWR _2721_ sky130_fd_sc_hd__a41o_1
XFILLER_0_99_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4931_ _1682_ _1683_ _1686_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4862_ _1239_ _1609_ _1617_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__o21ai_4
X_7650_ _3782_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6601_ _3209_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__clkbuf_1
X_7581_ _3041_ net1074 _3736_ VGND VGND VPWR VPWR _3746_ sky130_fd_sc_hd__mux2_1
X_9320_ clknet_leaf_101_CLK _0480_ VGND VGND VPWR VPWR regfile.registers\[21\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_4793_ _1545_ _1548_ _1037_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__mux2_2
XFILLER_0_103_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6532_ _3171_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9251_ clknet_leaf_83_CLK _0411_ VGND VGND VPWR VPWR regfile.registers\[18\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_6463_ net442 _3130_ _3114_ VGND VGND VPWR VPWR _3131_ sky130_fd_sc_hd__mux2_1
X_5414_ _1699_ _2169_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__nand2_1
X_9182_ clknet_leaf_72_CLK _0342_ VGND VGND VPWR VPWR regfile.registers\[30\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_8202_ _4075_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_33_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_33_CLK sky130_fd_sc_hd__clkbuf_8
X_6394_ net37 VGND VGND VPWR VPWR _3083_ sky130_fd_sc_hd__buf_2
XFILLER_0_88_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8133_ net590 _3517_ _4036_ VGND VGND VPWR VPWR _4039_ sky130_fd_sc_hd__mux2_1
X_5345_ _1664_ _1084_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5276_ _2026_ _2028_ _2031_ _1766_ _1672_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__o221a_1
X_8064_ _4002_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__clkbuf_1
X_7015_ _3429_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8966_ clknet_leaf_68_CLK _0126_ VGND VGND VPWR VPWR regfile.registers\[7\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_26_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7917_ _3107_ net400 _3916_ VGND VGND VPWR VPWR _3924_ sky130_fd_sc_hd__mux2_1
X_8897_ clknet_leaf_85_CLK _0057_ VGND VGND VPWR VPWR regfile.registers\[19\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_7848_ _3887_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__clkbuf_1
X_7779_ net1059 _3504_ _3844_ VGND VGND VPWR VPWR _3851_ sky130_fd_sc_hd__mux2_1
X_9518_ clknet_leaf_4_CLK _0678_ VGND VGND VPWR VPWR regfile.registers\[12\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9449_ clknet_leaf_99_CLK _0609_ VGND VGND VPWR VPWR regfile.registers\[13\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_24_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_24_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_6_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 A3[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_2
Xinput35 WD3[27] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_77_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput46 WD3[8] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_1
XFILLER_0_52_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput24 WD3[17] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
XFILLER_0_107_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold808 regfile.registers\[22\]\[16\] VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold819 regfile.registers\[21\]\[0\] VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_15_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_15_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_110_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5130_ regfile.registers\[28\]\[31\] regfile.registers\[29\]\[31\] regfile.registers\[30\]\[31\]
+ regfile.registers\[31\]\[31\] _1882_ _1884_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__mux4_1
X_5061_ regfile.registers\[0\]\[18\] regfile.registers\[1\]\[18\] regfile.registers\[2\]\[18\]
+ regfile.registers\[3\]\[18\] _1704_ _1707_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__mux4_1
XFILLER_0_74_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8820_ clknet_leaf_16_CLK _1004_ VGND VGND VPWR VPWR regfile.registers\[6\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_5963_ _2624_ _2704_ _2501_ VGND VGND VPWR VPWR _2705_ sky130_fd_sc_hd__mux2_1
X_8751_ clknet_leaf_7_CLK _0935_ VGND VGND VPWR VPWR regfile.registers\[8\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_7702_ _3810_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__clkbuf_1
X_4914_ _1640_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5894_ _2638_ net1139 _2593_ _2594_ VGND VGND VPWR VPWR _2639_ sky130_fd_sc_hd__or4_4
XFILLER_0_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8682_ clknet_leaf_8_CLK _0866_ VGND VGND VPWR VPWR regfile.registers\[0\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7633_ net262 _3494_ _3772_ VGND VGND VPWR VPWR _3774_ sky130_fd_sc_hd__mux2_1
X_4845_ _1215_ _1592_ _1596_ _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__a2bb2o_2
X_4776_ regfile.registers\[24\]\[9\] regfile.registers\[25\]\[9\] regfile.registers\[26\]\[9\]
+ regfile.registers\[27\]\[9\] _1290_ _1193_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__mux4_1
XFILLER_0_16_723 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7564_ _3737_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
X_9303_ clknet_leaf_35_CLK _0463_ VGND VGND VPWR VPWR regfile.registers\[25\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6515_ _3162_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7495_ _3019_ net726 _3700_ VGND VGND VPWR VPWR _3701_ sky130_fd_sc_hd__mux2_1
X_9234_ clknet_leaf_45_CLK _0394_ VGND VGND VPWR VPWR regfile.registers\[9\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6446_ _3119_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__clkbuf_1
X_6377_ _3071_ net973 _3065_ VGND VGND VPWR VPWR _3072_ sky130_fd_sc_hd__mux2_1
X_9165_ clknet_leaf_94_CLK _0325_ VGND VGND VPWR VPWR regfile.registers\[2\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_5328_ regfile.registers\[24\]\[1\] regfile.registers\[25\]\[1\] regfile.registers\[26\]\[1\]
+ regfile.registers\[27\]\[1\] _1673_ _1690_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__mux4_1
X_8116_ net733 _3500_ _4025_ VGND VGND VPWR VPWR _4030_ sky130_fd_sc_hd__mux2_1
X_9096_ clknet_leaf_102_CLK _0256_ VGND VGND VPWR VPWR regfile.registers\[27\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_8047_ _3993_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__clkbuf_1
X_5259_ _1777_ _2006_ _2010_ _2014_ VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_110_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8949_ clknet_leaf_32_CLK _0109_ VGND VGND VPWR VPWR regfile.registers\[3\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_4_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_4_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_29_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4630_ regfile.registers\[24\]\[6\] regfile.registers\[25\]\[6\] regfile.registers\[26\]\[6\]
+ regfile.registers\[27\]\[6\] _1219_ _1221_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6300_ _3018_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__clkbuf_1
X_4561_ regfile.registers\[20\]\[31\] regfile.registers\[21\]\[31\] regfile.registers\[22\]\[31\]
+ regfile.registers\[23\]\[31\] _1200_ _1202_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold605 regfile.registers\[27\]\[29\] VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlygate4sd3_1
X_7280_ net472 _3484_ _3575_ VGND VGND VPWR VPWR _3585_ sky130_fd_sc_hd__mux2_1
X_4492_ _1190_ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__or2_1
Xhold616 regfile.registers\[12\]\[30\] VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold627 regfile.registers\[21\]\[10\] VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlygate4sd3_1
X_6231_ _2380_ _2383_ VGND VGND VPWR VPWR _2958_ sky130_fd_sc_hd__or2b_1
Xhold638 regfile.registers\[30\]\[28\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_100_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold649 regfile.registers\[19\]\[14\] VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dlygate4sd3_1
X_6162_ _2891_ _2892_ VGND VGND VPWR VPWR _2893_ sky130_fd_sc_hd__or2_1
XFILLER_0_110_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5113_ _1717_ _1868_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6093_ _1512_ net88 _1635_ _2658_ _2741_ VGND VGND VPWR VPWR _2828_ sky130_fd_sc_hd__a41o_1
X_5044_ _1799_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__buf_2
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8803_ clknet_leaf_90_CLK _0987_ VGND VGND VPWR VPWR regfile.registers\[6\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6995_ net471 _3105_ _3412_ VGND VGND VPWR VPWR _3419_ sky130_fd_sc_hd__mux2_1
X_5946_ _2687_ _2688_ VGND VGND VPWR VPWR _2689_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_36_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8734_ clknet_leaf_74_CLK _0918_ VGND VGND VPWR VPWR regfile.registers\[8\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8665_ clknet_leaf_37_CLK _0849_ VGND VGND VPWR VPWR regfile.registers\[22\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_5877_ _2581_ _2622_ _1146_ VGND VGND VPWR VPWR _2623_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7616_ _3764_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
Xclone16 net100 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4828_ regfile.registers\[0\]\[16\] regfile.registers\[1\]\[16\] regfile.registers\[2\]\[16\]
+ regfile.registers\[3\]\[16\] _1181_ _1183_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__mux4_1
X_8596_ clknet_leaf_22_CLK _0780_ VGND VGND VPWR VPWR regfile.registers\[23\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone38 _1026_ VGND VGND VPWR VPWR net1147 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_121_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7547_ _3075_ net549 _3722_ VGND VGND VPWR VPWR _3728_ sky130_fd_sc_hd__mux2_1
X_4759_ _1513_ _1514_ _1035_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7478_ _3691_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
X_6429_ net259 _3107_ _3093_ VGND VGND VPWR VPWR _3108_ sky130_fd_sc_hd__mux2_1
X_9217_ clknet_leaf_90_CLK _0377_ VGND VGND VPWR VPWR regfile.registers\[9\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9148_ clknet_leaf_41_CLK _0308_ VGND VGND VPWR VPWR regfile.registers\[28\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_9079_ clknet_leaf_35_CLK _0239_ VGND VGND VPWR VPWR regfile.registers\[26\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_7__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_7__leaf_CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5800_ _2439_ _2424_ _2501_ VGND VGND VPWR VPWR _2550_ sky130_fd_sc_hd__mux2_1
X_6780_ _3025_ net983 _3303_ VGND VGND VPWR VPWR _3305_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5731_ _2449_ _2451_ _2483_ VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_33_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5662_ _2376_ _2407_ _2408_ _2416_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__o2bb2a_2
X_8450_ net609 net27 _4205_ VGND VGND VPWR VPWR _4207_ sky130_fd_sc_hd__mux2_1
X_4613_ _1214_ _1368_ _1239_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__o21ai_1
X_5593_ _2343_ _2346_ _2347_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__mux2_1
X_7401_ _3650_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8381_ _4170_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__clkbuf_1
X_4544_ regfile.registers\[20\]\[27\] regfile.registers\[21\]\[27\] regfile.registers\[22\]\[27\]
+ regfile.registers\[23\]\[27\] _1262_ _1263_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__mux4_1
Xhold402 regfile.registers\[18\]\[29\] VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlygate4sd3_1
X_7332_ _3064_ net584 _3613_ VGND VGND VPWR VPWR _3614_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_96_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold413 regfile.registers\[20\]\[20\] VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold424 regfile.registers\[8\]\[22\] VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__dlygate4sd3_1
X_7263_ _3576_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
Xhold435 regfile.registers\[13\]\[31\] VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__dlygate4sd3_1
Xhold446 regfile.registers\[8\]\[21\] VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6214_ _2426_ _2591_ VGND VGND VPWR VPWR _2942_ sky130_fd_sc_hd__nand2_1
Xhold457 regfile.registers\[4\]\[23\] VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__dlygate4sd3_1
X_4475_ regfile.registers\[0\]\[28\] regfile.registers\[1\]\[28\] regfile.registers\[2\]\[28\]
+ regfile.registers\[3\]\[28\] _1207_ _1208_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__mux4_1
X_9002_ clknet_leaf_104_CLK _0162_ VGND VGND VPWR VPWR regfile.registers\[29\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold468 regfile.registers\[1\]\[15\] VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__dlygate4sd3_1
X_7194_ net30 VGND VGND VPWR VPWR _3538_ sky130_fd_sc_hd__buf_2
Xhold479 regfile.registers\[8\]\[3\] VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__dlygate4sd3_1
X_6145_ _2875_ _2876_ VGND VGND VPWR VPWR _2877_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6076_ _2773_ _2809_ _2810_ _2811_ VGND VGND VPWR VPWR _2812_ sky130_fd_sc_hd__o211a_1
X_5027_ regfile.registers\[20\]\[20\] regfile.registers\[21\]\[20\] regfile.registers\[22\]\[20\]
+ regfile.registers\[23\]\[20\] _1782_ _1680_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__mux4_1
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6978_ _3409_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_8717_ clknet_leaf_97_CLK _0901_ VGND VGND VPWR VPWR regfile.registers\[15\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_5929_ _2547_ _2672_ _1147_ VGND VGND VPWR VPWR _2673_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8648_ clknet_leaf_101_CLK _0832_ VGND VGND VPWR VPWR regfile.registers\[22\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8579_ clknet_leaf_84_CLK _0763_ VGND VGND VPWR VPWR regfile.registers\[23\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_56_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold980 regfile.registers\[25\]\[10\] VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold991 regfile.registers\[13\]\[1\] VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_116_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7950_ _3941_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7881_ net481 _3538_ _3902_ VGND VGND VPWR VPWR _3905_ sky130_fd_sc_hd__mux2_1
X_6901_ net172 _3002_ _3362_ VGND VGND VPWR VPWR _3369_ sky130_fd_sc_hd__mux2_1
X_6832_ _3077_ net976 _3325_ VGND VGND VPWR VPWR _3332_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6763_ _3295_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9551_ clknet_leaf_3_CLK _0711_ VGND VGND VPWR VPWR regfile.registers\[11\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_6694_ _3075_ net996 _3253_ VGND VGND VPWR VPWR _3259_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5714_ _2105_ _2462_ _2466_ VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__o21a_1
X_8502_ net785 net34 _4227_ VGND VGND VPWR VPWR _4234_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9482_ clknet_leaf_105_CLK _0642_ VGND VGND VPWR VPWR regfile.registers\[16\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_8433_ _4197_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__clkbuf_1
X_5645_ _2398_ _2399_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__and2b_1
XFILLER_0_73_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8364_ net578 _3544_ _4155_ VGND VGND VPWR VPWR _4161_ sky130_fd_sc_hd__mux2_1
Xhold210 regfile.registers\[2\]\[29\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
X_5576_ _1669_ _1660_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold232 regfile.registers\[0\]\[21\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
X_8295_ _4124_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__clkbuf_1
X_4527_ regfile.registers\[28\]\[26\] regfile.registers\[29\]\[26\] regfile.registers\[30\]\[26\]
+ regfile.registers\[31\]\[26\] _1181_ _1183_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__mux4_1
Xhold243 regfile.registers\[10\]\[8\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 regfile.registers\[5\]\[16\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
X_7315_ _3048_ net864 _3602_ VGND VGND VPWR VPWR _3605_ sky130_fd_sc_hd__mux2_1
XFILLER_0_111_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4458_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__buf_4
Xhold276 regfile.registers\[20\]\[16\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
Xhold287 regfile.registers\[31\]\[9\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
X_7246_ _3567_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
Xhold265 regfile.registers\[10\]\[15\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
Xhold254 regfile.registers\[11\]\[0\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold298 regfile.registers\[10\]\[27\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
X_7177_ _3526_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
X_6128_ _2373_ _2572_ _2823_ _2569_ _2860_ VGND VGND VPWR VPWR _2861_ sky130_fd_sc_hd__a221o_1
X_4389_ _1144_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6059_ _2102_ _2488_ VGND VGND VPWR VPWR _2795_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_107_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_120_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5430_ regfile.registers\[8\]\[11\] regfile.registers\[9\]\[11\] regfile.registers\[10\]\[11\]
+ regfile.registers\[11\]\[11\] _2117_ _2118_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__mux4_1
XFILLER_0_125_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5361_ _1702_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__buf_4
X_7100_ net193 _3141_ _3471_ VGND VGND VPWR VPWR _3475_ sky130_fd_sc_hd__mux2_1
X_8080_ _4010_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__clkbuf_1
X_5292_ _2046_ _2047_ _2044_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__mux2_1
X_4312_ regfile.registers\[24\]\[5\] regfile.registers\[25\]\[5\] regfile.registers\[26\]\[5\]
+ regfile.registers\[27\]\[5\] net91 _1066_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7031_ net537 _3141_ _3434_ VGND VGND VPWR VPWR _3438_ sky130_fd_sc_hd__mux2_1
X_8982_ clknet_leaf_50_CLK _0142_ VGND VGND VPWR VPWR regfile.registers\[7\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_7933_ _3932_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7864_ net451 _3521_ _3891_ VGND VGND VPWR VPWR _3896_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7795_ _3859_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__clkbuf_1
X_6815_ _3060_ net916 _3314_ VGND VGND VPWR VPWR _3323_ sky130_fd_sc_hd__mux2_1
XFILLER_0_108_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9534_ clknet_leaf_65_CLK _0694_ VGND VGND VPWR VPWR regfile.registers\[11\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_6746_ _3286_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9465_ clknet_leaf_38_CLK _0625_ VGND VGND VPWR VPWR regfile.registers\[13\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_21_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6677_ _3058_ net1063 _3242_ VGND VGND VPWR VPWR _3250_ sky130_fd_sc_hd__mux2_1
X_5628_ _1668_ _1959_ VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9396_ clknet_leaf_23_CLK _0556_ VGND VGND VPWR VPWR regfile.registers\[24\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_8416_ _4188_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5559_ regfile.registers\[8\]\[5\] regfile.registers\[9\]\[5\] regfile.registers\[10\]\[5\]
+ regfile.registers\[11\]\[5\] _1718_ _1721_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__mux4_1
X_8347_ net845 _3527_ _4144_ VGND VGND VPWR VPWR _4152_ sky130_fd_sc_hd__mux2_1
X_8278_ _4115_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__clkbuf_1
X_7229_ _3558_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_CLK CLK VGND VGND VPWR VPWR clknet_0_CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_0_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4930_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__buf_6
XFILLER_0_129_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4861_ _1611_ _1613_ _1616_ _1214_ _1170_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__a221o_1
X_6600_ net872 _3120_ _3205_ VGND VGND VPWR VPWR _3209_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7580_ _3745_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
X_4792_ _1546_ _1547_ _1034_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6531_ _3052_ net1112 _3166_ VGND VGND VPWR VPWR _3171_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9250_ clknet_leaf_86_CLK _0410_ VGND VGND VPWR VPWR regfile.registers\[18\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6462_ net25 VGND VGND VPWR VPWR _3130_ sky130_fd_sc_hd__buf_2
XFILLER_0_125_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6393_ _3082_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__clkbuf_1
X_9181_ clknet_leaf_12_CLK _0341_ VGND VGND VPWR VPWR regfile.registers\[2\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_5413_ _2167_ _2168_ _1711_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8201_ net158 _3517_ _4072_ VGND VGND VPWR VPWR _4075_ sky130_fd_sc_hd__mux2_1
X_5344_ _2083_ _2099_ _1148_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__mux2_1
X_8132_ _4038_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5275_ _2029_ _2030_ _1901_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__mux2_1
X_8063_ net297 _3515_ _4000_ VGND VGND VPWR VPWR _4002_ sky130_fd_sc_hd__mux2_1
X_7014_ net240 _3124_ _3423_ VGND VGND VPWR VPWR _3429_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8965_ clknet_leaf_93_CLK _0125_ VGND VGND VPWR VPWR regfile.registers\[7\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8896_ clknet_leaf_76_CLK _0056_ VGND VGND VPWR VPWR regfile.registers\[19\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_7916_ _3923_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7847_ net503 _3504_ _3880_ VGND VGND VPWR VPWR _3887_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7778_ _3850_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__clkbuf_1
X_6729_ _3277_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__clkbuf_1
X_9517_ clknet_leaf_95_CLK _0677_ VGND VGND VPWR VPWR regfile.registers\[12\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9448_ clknet_leaf_100_CLK _0608_ VGND VGND VPWR VPWR regfile.registers\[13\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_115_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9379_ clknet_leaf_80_CLK _0539_ VGND VGND VPWR VPWR regfile.registers\[24\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_6_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput36 WD3[28] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput14 ALUOp[0] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
Xinput25 WD3[18] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_122_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput47 WD3[9] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold809 regfile.registers\[4\]\[17\] VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_58_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5060_ regfile.registers\[4\]\[18\] regfile.registers\[5\]\[18\] regfile.registers\[6\]\[18\]
+ regfile.registers\[7\]\[18\] _1704_ _1707_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_88_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5962_ _2675_ _2703_ _2347_ VGND VGND VPWR VPWR _2704_ sky130_fd_sc_hd__mux2_1
X_8750_ clknet_leaf_19_CLK _0934_ VGND VGND VPWR VPWR regfile.registers\[8\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_4913_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__clkbuf_4
X_7701_ _3025_ net911 _3808_ VGND VGND VPWR VPWR _3810_ sky130_fd_sc_hd__mux2_1
X_5893_ _1528_ _1542_ _1558_ VGND VGND VPWR VPWR _2638_ sky130_fd_sc_hd__nand3b_1
X_8681_ clknet_leaf_95_CLK _0865_ VGND VGND VPWR VPWR regfile.registers\[0\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4844_ _1205_ _1599_ _1057_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__a21oi_1
X_7632_ _3773_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4775_ regfile.registers\[28\]\[9\] regfile.registers\[29\]\[9\] regfile.registers\[30\]\[9\]
+ regfile.registers\[31\]\[9\] _1290_ _1193_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__mux4_1
XFILLER_0_16_735 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7563_ _3019_ net896 _3736_ VGND VGND VPWR VPWR _3737_ sky130_fd_sc_hd__mux2_1
X_9302_ clknet_leaf_52_CLK _0462_ VGND VGND VPWR VPWR regfile.registers\[25\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6514_ _3035_ net783 _3155_ VGND VGND VPWR VPWR _3162_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9233_ clknet_leaf_19_CLK _0393_ VGND VGND VPWR VPWR regfile.registers\[9\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_7494_ _3699_ VGND VGND VPWR VPWR _3700_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_31_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6445_ net120 _3118_ _3114_ VGND VGND VPWR VPWR _3119_ sky130_fd_sc_hd__mux2_1
X_6376_ net31 VGND VGND VPWR VPWR _3071_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9164_ clknet_leaf_0_CLK _0324_ VGND VGND VPWR VPWR regfile.registers\[2\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_5327_ _2064_ _2082_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__and2_1
X_9095_ clknet_leaf_61_CLK _0255_ VGND VGND VPWR VPWR regfile.registers\[27\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_8115_ _4029_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__clkbuf_1
X_8046_ net443 _3498_ _3989_ VGND VGND VPWR VPWR _3993_ sky130_fd_sc_hd__mux2_1
X_5258_ _1766_ _2013_ _1672_ VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_110_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5189_ regfile.registers\[24\]\[28\] regfile.registers\[25\]\[28\] regfile.registers\[26\]\[28\]
+ regfile.registers\[27\]\[28\] _1882_ _1884_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_3_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8948_ clknet_leaf_16_CLK _0108_ VGND VGND VPWR VPWR regfile.registers\[3\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8879_ clknet_leaf_7_CLK _0039_ VGND VGND VPWR VPWR regfile.registers\[4\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4560_ _1299_ _1315_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold617 regfile.registers\[5\]\[29\] VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_80_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4491_ regfile.registers\[8\]\[20\] regfile.registers\[9\]\[20\] regfile.registers\[10\]\[20\]
+ regfile.registers\[11\]\[20\] _1201_ _1203_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__mux4_1
Xhold606 regfile.registers\[28\]\[15\] VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6230_ _2955_ _2503_ _2956_ VGND VGND VPWR VPWR _2957_ sky130_fd_sc_hd__and3_1
Xhold628 regfile.registers\[27\]\[20\] VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlygate4sd3_1
Xhold639 regfile.registers\[30\]\[20\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6161_ _2015_ _2889_ VGND VGND VPWR VPWR _2892_ sky130_fd_sc_hd__nor2_1
X_5112_ _1866_ _1867_ _1713_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__mux2_1
X_6092_ _2812_ _2817_ _2808_ VGND VGND VPWR VPWR _2827_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5043_ _1167_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__buf_2
X_8802_ clknet_leaf_88_CLK _0986_ VGND VGND VPWR VPWR regfile.registers\[6\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_6994_ _3418_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5945_ net108 _2686_ _2160_ VGND VGND VPWR VPWR _2688_ sky130_fd_sc_hd__a21oi_2
X_8733_ clknet_leaf_14_CLK _0917_ VGND VGND VPWR VPWR regfile.registers\[15\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5876_ _1839_ _2211_ _2248_ VGND VGND VPWR VPWR _2622_ sky130_fd_sc_hd__o21a_1
X_8664_ clknet_leaf_20_CLK _0848_ VGND VGND VPWR VPWR regfile.registers\[22\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7615_ _3075_ net695 _3758_ VGND VGND VPWR VPWR _3764_ sky130_fd_sc_hd__mux2_1
XFILLER_0_118_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4827_ regfile.registers\[4\]\[16\] regfile.registers\[5\]\[16\] regfile.registers\[6\]\[16\]
+ regfile.registers\[7\]\[16\] _1181_ _1183_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone17 net100 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8595_ clknet_leaf_27_CLK _0779_ VGND VGND VPWR VPWR regfile.registers\[23\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7546_ _3727_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
X_4758_ regfile.registers\[16\]\[8\] regfile.registers\[17\]\[8\] regfile.registers\[18\]\[8\]
+ regfile.registers\[19\]\[8\] _1026_ _1061_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__mux4_1
X_7477_ _3073_ net1018 _3686_ VGND VGND VPWR VPWR _3691_ sky130_fd_sc_hd__mux2_1
X_4689_ _1439_ _1441_ _1444_ _1254_ _1170_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__a221o_1
X_6428_ net45 VGND VGND VPWR VPWR _3107_ sky130_fd_sc_hd__buf_2
X_9216_ clknet_leaf_75_CLK _0376_ VGND VGND VPWR VPWR regfile.registers\[9\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_9147_ clknet_leaf_25_CLK _0307_ VGND VGND VPWR VPWR regfile.registers\[28\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_6359_ _3059_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_128_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9078_ clknet_leaf_51_CLK _0238_ VGND VGND VPWR VPWR regfile.registers\[26\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_8029_ _3011_ net883 _3974_ VGND VGND VPWR VPWR _3983_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_123_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5730_ _2080_ _2448_ VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7400_ _3064_ net626 _3649_ VGND VGND VPWR VPWR _3650_ sky130_fd_sc_hd__mux2_1
X_5661_ _2332_ _2415_ VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4612_ _1366_ _1367_ _1199_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__mux2_1
X_5592_ _1146_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__clkbuf_4
X_8380_ net762 _3490_ _4169_ VGND VGND VPWR VPWR _4170_ sky130_fd_sc_hd__mux2_1
X_4543_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__inv_2
X_7331_ _3590_ VGND VGND VPWR VPWR _3613_ sky130_fd_sc_hd__clkbuf_8
Xhold425 regfile.registers\[24\]\[21\] VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__dlygate4sd3_1
Xhold403 regfile.registers\[3\]\[29\] VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7262_ net142 _3533_ _3575_ VGND VGND VPWR VPWR _3576_ sky130_fd_sc_hd__mux2_1
Xhold414 regfile.registers\[21\]\[12\] VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold436 regfile.registers\[31\]\[16\] VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__dlygate4sd3_1
Xhold447 regfile.registers\[30\]\[25\] VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__dlygate4sd3_1
Xhold469 regfile.registers\[27\]\[25\] VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6213_ _2934_ _2940_ VGND VGND VPWR VPWR _2941_ sky130_fd_sc_hd__xor2_1
X_4474_ _1189_ _1229_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__and2_1
Xhold458 regfile.registers\[12\]\[9\] VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__dlygate4sd3_1
X_9001_ clknet_leaf_102_CLK _0161_ VGND VGND VPWR VPWR regfile.registers\[29\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7193_ _3537_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
X_6144_ _2033_ _2874_ VGND VGND VPWR VPWR _2876_ sky130_fd_sc_hd__and2_1
X_6075_ _1838_ _2783_ VGND VGND VPWR VPWR _2811_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5026_ _1733_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6977_ net558 _3015_ _3375_ VGND VGND VPWR VPWR _3409_ sky130_fd_sc_hd__mux2_1
X_5928_ _2428_ _2288_ VGND VGND VPWR VPWR _2672_ sky130_fd_sc_hd__nor2_1
X_8716_ clknet_leaf_110_CLK _0900_ VGND VGND VPWR VPWR regfile.registers\[15\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_105_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5859_ _2404_ _2605_ _2591_ _2356_ VGND VGND VPWR VPWR _2606_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8647_ clknet_leaf_60_CLK _0831_ VGND VGND VPWR VPWR regfile.registers\[22\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_8578_ clknet_leaf_85_CLK _0762_ VGND VGND VPWR VPWR regfile.registers\[23\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_7529_ _3718_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold970 regfile.registers\[15\]\[0\] VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__dlygate4sd3_1
Xhold981 regfile.registers\[0\]\[7\] VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__dlygate4sd3_1
Xhold992 regfile.registers\[25\]\[28\] VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_711 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7880_ _3904_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__clkbuf_1
X_6900_ _3368_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6831_ _3331_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9550_ clknet_leaf_20_CLK _0710_ VGND VGND VPWR VPWR regfile.registers\[11\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8501_ _4233_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__clkbuf_1
X_6762_ net414 _3145_ _3289_ VGND VGND VPWR VPWR _3295_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6693_ _3258_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__clkbuf_1
X_5713_ _2255_ _2463_ _2465_ _2373_ VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__o211a_1
X_9481_ clknet_leaf_101_CLK _0641_ VGND VGND VPWR VPWR regfile.registers\[16\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_8432_ net250 _3544_ _4191_ VGND VGND VPWR VPWR _4197_ sky130_fd_sc_hd__mux2_1
X_5644_ _1842_ _1838_ _1799_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_98_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8363_ _4160_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_28_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5575_ _1669_ _1660_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__or2_1
Xhold200 regfile.registers\[11\]\[19\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
X_7314_ _3604_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
Xhold211 regfile.registers\[6\]\[2\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 regfile.registers\[20\]\[24\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
X_8294_ _3143_ net768 _4119_ VGND VGND VPWR VPWR _4124_ sky130_fd_sc_hd__mux2_1
Xhold244 regfile.registers\[12\]\[26\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
X_4526_ _1280_ _1281_ _1198_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__mux2_1
Xhold222 regfile.registers\[15\]\[8\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold266 regfile.registers\[25\]\[30\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold277 regfile.registers\[8\]\[30\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
Xhold255 regfile.registers\[12\]\[19\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
X_4457_ _1038_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__buf_4
X_7245_ net205 _3517_ _3564_ VGND VGND VPWR VPWR _3567_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold288 regfile.registers\[21\]\[14\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
Xhold299 regfile.registers\[7\]\[10\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
X_7176_ net593 _3525_ _3513_ VGND VGND VPWR VPWR _3526_ sky130_fd_sc_hd__mux2_1
X_6127_ _2719_ _2731_ VGND VGND VPWR VPWR _2860_ sky130_fd_sc_hd__and2_1
X_4388_ _1025_ _1135_ _1139_ _1143_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__a2bb2o_4
XPHY_EDGE_ROW_0_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6058_ _2373_ _2476_ _2789_ _2794_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__a211o_1
X_5009_ _1761_ _1764_ _1697_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_118_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5360_ _1685_ _2115_ _1696_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__o21a_1
X_5291_ regfile.registers\[24\]\[3\] regfile.registers\[25\]\[3\] regfile.registers\[26\]\[3\]
+ regfile.registers\[27\]\[3\] _1674_ _1691_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__mux4_1
X_4311_ regfile.registers\[28\]\[5\] regfile.registers\[29\]\[5\] regfile.registers\[30\]\[5\]
+ regfile.registers\[31\]\[5\] net91 _1066_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__mux4_1
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7030_ _3437_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_8981_ clknet_leaf_31_CLK _0141_ VGND VGND VPWR VPWR regfile.registers\[7\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7932_ _3122_ net873 _3927_ VGND VGND VPWR VPWR _3932_ sky130_fd_sc_hd__mux2_1
X_7863_ _3895_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__clkbuf_1
X_7794_ net580 _3519_ _3855_ VGND VGND VPWR VPWR _3859_ sky130_fd_sc_hd__mux2_1
X_6814_ _3322_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_102_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9533_ clknet_leaf_13_CLK _0693_ VGND VGND VPWR VPWR regfile.registers\[12\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6745_ net630 _3128_ _3278_ VGND VGND VPWR VPWR _3286_ sky130_fd_sc_hd__mux2_1
X_9464_ clknet_leaf_17_CLK _0624_ VGND VGND VPWR VPWR regfile.registers\[13\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6676_ _3249_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_21_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8415_ net528 _3527_ _4180_ VGND VGND VPWR VPWR _4188_ sky130_fd_sc_hd__mux2_1
X_9395_ clknet_leaf_28_CLK _0555_ VGND VGND VPWR VPWR regfile.registers\[24\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5627_ _2378_ _2381_ _1877_ VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__mux2_1
X_5558_ _2310_ _2313_ net4 VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__mux2_1
X_8346_ _4151_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__clkbuf_1
X_4509_ _1261_ _1264_ _1259_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__mux2_1
X_8277_ _3126_ net449 _4108_ VGND VGND VPWR VPWR _4115_ sky130_fd_sc_hd__mux2_1
X_5489_ _1697_ _2240_ _2242_ _2244_ _1729_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__a221o_1
X_7228_ net497 _3500_ _3553_ VGND VGND VPWR VPWR _3558_ sky130_fd_sc_hd__mux2_1
X_7159_ _3514_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_72_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4860_ _1614_ _1615_ _1189_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4791_ regfile.registers\[24\]\[10\] regfile.registers\[25\]\[10\] regfile.registers\[26\]\[10\]
+ regfile.registers\[27\]\[10\] net86 _1043_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__mux4_1
X_6530_ _3170_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6461_ _3129_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6392_ _3081_ net852 _3065_ VGND VGND VPWR VPWR _3082_ sky130_fd_sc_hd__mux2_1
X_9180_ clknet_leaf_42_CLK _0340_ VGND VGND VPWR VPWR regfile.registers\[2\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5412_ regfile.registers\[12\]\[12\] regfile.registers\[13\]\[12\] regfile.registers\[14\]\[12\]
+ regfile.registers\[15\]\[12\] _2117_ _2118_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__mux4_1
X_8200_ _4074_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_81_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5343_ _1167_ _2098_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8131_ net352 _3515_ _4036_ VGND VGND VPWR VPWR _4038_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5274_ regfile.registers\[0\]\[24\] regfile.registers\[1\]\[24\] regfile.registers\[2\]\[24\]
+ regfile.registers\[3\]\[24\] _1918_ _1919_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__mux4_1
X_8062_ _4001_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7013_ _3428_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_110_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_110_CLK
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_128_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8964_ clknet_leaf_93_CLK _0124_ VGND VGND VPWR VPWR regfile.registers\[7\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8895_ clknet_leaf_81_CLK _0055_ VGND VGND VPWR VPWR regfile.registers\[19\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_26_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7915_ _3105_ net682 _3916_ VGND VGND VPWR VPWR _3923_ sky130_fd_sc_hd__mux2_1
X_7846_ _3886_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4989_ _1686_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__buf_4
XFILLER_0_108_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_755 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7777_ net114 _3502_ _3844_ VGND VGND VPWR VPWR _3850_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6728_ net233 _3111_ _3267_ VGND VGND VPWR VPWR _3277_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9516_ clknet_leaf_0_CLK _0676_ VGND VGND VPWR VPWR regfile.registers\[12\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6659_ _3240_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__clkbuf_1
X_9447_ clknet_leaf_63_CLK _0607_ VGND VGND VPWR VPWR regfile.registers\[13\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_9378_ clknet_leaf_85_CLK _0538_ VGND VGND VPWR VPWR regfile.registers\[24\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8329_ _4142_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_101_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_101_CLK
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput37 WD3[29] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput15 ALUOp[1] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_2
Xinput26 WD3[19] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput48 WE3 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5961_ _2161_ _2142_ VGND VGND VPWR VPWR _2703_ sky130_fd_sc_hd__nor2_1
XFILLER_0_90_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4912_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__buf_2
X_7700_ _3809_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_1
X_8680_ clknet_leaf_92_CLK _0864_ VGND VGND VPWR VPWR regfile.registers\[0\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5892_ _2627_ _2629_ _2637_ _2621_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__o22a_1
XFILLER_0_75_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7631_ net164 _3490_ _3772_ VGND VGND VPWR VPWR _3773_ sky130_fd_sc_hd__mux2_1
XFILLER_0_118_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4843_ _1597_ _1598_ _1036_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__mux2_1
X_7562_ _3735_ VGND VGND VPWR VPWR _3736_ sky130_fd_sc_hd__clkbuf_8
X_4774_ regfile.registers\[16\]\[9\] regfile.registers\[17\]\[9\] regfile.registers\[18\]\[9\]
+ regfile.registers\[19\]\[9\] _1072_ _1073_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9301_ clknet_leaf_29_CLK _0461_ VGND VGND VPWR VPWR regfile.registers\[25\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_7493_ _3021_ _3662_ VGND VGND VPWR VPWR _3699_ sky130_fd_sc_hd__nand2_4
X_6513_ _3161_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9232_ clknet_leaf_6_CLK _0392_ VGND VGND VPWR VPWR regfile.registers\[9\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6444_ net19 VGND VGND VPWR VPWR _3118_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_31_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6375_ _3070_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9163_ clknet_leaf_98_CLK _0323_ VGND VGND VPWR VPWR regfile.registers\[2\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_5326_ _1168_ _2081_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__nand2_1
X_9094_ clknet_leaf_68_CLK _0254_ VGND VGND VPWR VPWR regfile.registers\[27\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8114_ net607 _3498_ _4025_ VGND VGND VPWR VPWR _4029_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5257_ _2011_ _2012_ _1745_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__mux2_1
X_8045_ _3992_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_110_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5188_ _1800_ _1943_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_3_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8947_ clknet_leaf_33_CLK _0107_ VGND VGND VPWR VPWR regfile.registers\[3\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8878_ clknet_leaf_6_CLK _0038_ VGND VGND VPWR VPWR regfile.registers\[4\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7829_ net655 _3486_ _3843_ VGND VGND VPWR VPWR _3877_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_61_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4490_ _1242_ _1245_ _1187_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__mux2_2
XFILLER_0_80_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold618 regfile.registers\[4\]\[16\] VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlygate4sd3_1
Xhold607 regfile.registers\[4\]\[7\] VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_750 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold629 regfile.registers\[13\]\[10\] VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlygate4sd3_1
X_6160_ _2890_ VGND VGND VPWR VPWR _2891_ sky130_fd_sc_hd__inv_2
XFILLER_0_110_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5111_ regfile.registers\[12\]\[16\] regfile.registers\[13\]\[16\] regfile.registers\[14\]\[16\]
+ regfile.registers\[15\]\[16\] _1720_ _1723_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__mux4_1
X_6091_ _2528_ _2823_ _2731_ _2824_ _2825_ VGND VGND VPWR VPWR _2826_ sky130_fd_sc_hd__a221o_1
X_5042_ _1729_ _1789_ _1797_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8801_ clknet_leaf_90_CLK _0985_ VGND VGND VPWR VPWR regfile.registers\[6\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6993_ net1136 _3103_ _3412_ VGND VGND VPWR VPWR _3418_ sky130_fd_sc_hd__mux2_1
X_8732_ clknet_leaf_15_CLK _0916_ VGND VGND VPWR VPWR regfile.registers\[15\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_5944_ _2686_ _2684_ _2160_ VGND VGND VPWR VPWR _2687_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8663_ clknet_leaf_35_CLK _0847_ VGND VGND VPWR VPWR regfile.registers\[22\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5875_ _2607_ _2614_ _2620_ _2621_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__o22a_1
XFILLER_0_47_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7614_ _3763_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_118_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8594_ clknet_leaf_46_CLK _0778_ VGND VGND VPWR VPWR regfile.registers\[23\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4826_ _1213_ _1581_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7545_ _3073_ net793 _3722_ VGND VGND VPWR VPWR _3727_ sky130_fd_sc_hd__mux2_1
Xclone18 net100 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_16
X_4757_ regfile.registers\[20\]\[8\] regfile.registers\[21\]\[8\] regfile.registers\[22\]\[8\]
+ regfile.registers\[23\]\[8\] _1026_ _1061_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__mux4_2
XFILLER_0_16_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7476_ _3690_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
X_4688_ _1442_ _1443_ _1211_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9215_ clknet_leaf_82_CLK _0375_ VGND VGND VPWR VPWR regfile.registers\[9\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6427_ _3106_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__clkbuf_1
X_9146_ clknet_leaf_25_CLK _0306_ VGND VGND VPWR VPWR regfile.registers\[28\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_6358_ _3058_ net947 _3044_ VGND VGND VPWR VPWR _3059_ sky130_fd_sc_hd__mux2_1
X_5309_ regfile.registers\[20\]\[2\] regfile.registers\[21\]\[2\] regfile.registers\[22\]\[2\]
+ regfile.registers\[23\]\[2\] _1701_ _1677_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__mux4_1
X_9077_ clknet_leaf_29_CLK _0237_ VGND VGND VPWR VPWR regfile.registers\[26\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_6289_ net36 VGND VGND VPWR VPWR _3011_ sky130_fd_sc_hd__buf_2
X_8028_ _3982_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_123_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5660_ _2413_ _2414_ VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__or2_1
X_4611_ regfile.registers\[0\]\[25\] regfile.registers\[1\]\[25\] regfile.registers\[2\]\[25\]
+ regfile.registers\[3\]\[25\] _1360_ _1361_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_13_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5591_ _2344_ _2345_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4542_ _1170_ _1286_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__a21o_4
X_7330_ _3612_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_90_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_90_CLK sky130_fd_sc_hd__clkbuf_8
Xhold415 regfile.registers\[19\]\[24\] VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_711 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4473_ regfile.registers\[4\]\[28\] regfile.registers\[5\]\[28\] regfile.registers\[6\]\[28\]
+ regfile.registers\[7\]\[28\] _1207_ _1208_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_96_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7261_ _3552_ VGND VGND VPWR VPWR _3575_ sky130_fd_sc_hd__clkbuf_8
Xhold404 regfile.registers\[6\]\[20\] VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__dlygate4sd3_1
Xhold426 regfile.registers\[22\]\[4\] VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__dlygate4sd3_1
X_6212_ _2885_ _2936_ _2939_ VGND VGND VPWR VPWR _2940_ sky130_fd_sc_hd__a21bo_1
Xhold437 regfile.registers\[25\]\[19\] VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__dlygate4sd3_1
Xhold459 regfile.registers\[18\]\[15\] VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__dlygate4sd3_1
X_9000_ clknet_leaf_102_CLK _0160_ VGND VGND VPWR VPWR regfile.registers\[29\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold448 regfile.registers\[12\]\[17\] VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__dlygate4sd3_1
X_7192_ net1131 _3536_ _3534_ VGND VGND VPWR VPWR _3537_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6143_ _2033_ _2874_ VGND VGND VPWR VPWR _2875_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6074_ _1838_ _2783_ _2768_ _1820_ VGND VGND VPWR VPWR _2810_ sky130_fd_sc_hd__a211o_1
X_5025_ _1168_ _1780_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6976_ _3408_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
X_5927_ _2669_ _2670_ VGND VGND VPWR VPWR _2671_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8715_ clknet_leaf_98_CLK _0899_ VGND VGND VPWR VPWR regfile.registers\[15\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5858_ _1111_ _2102_ VGND VGND VPWR VPWR _2605_ sky130_fd_sc_hd__nor2_1
X_8646_ clknet_leaf_55_CLK _0830_ VGND VGND VPWR VPWR regfile.registers\[22\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_5789_ _2271_ _2538_ VGND VGND VPWR VPWR _2539_ sky130_fd_sc_hd__and2_1
X_8577_ clknet_leaf_84_CLK _0761_ VGND VGND VPWR VPWR regfile.registers\[23\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4809_ regfile.registers\[12\]\[11\] regfile.registers\[13\]\[11\] regfile.registers\[14\]\[11\]
+ regfile.registers\[15\]\[11\] net98 _1053_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7528_ _3056_ net780 _3711_ VGND VGND VPWR VPWR _3718_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_81_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_81_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_44_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7459_ _3681_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_102_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_56_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold971 regfile.registers\[26\]\[9\] VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__dlygate4sd3_1
Xhold982 regfile.registers\[25\]\[5\] VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold960 regfile.registers\[28\]\[3\] VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold993 regfile.registers\[23\]\[12\] VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__dlygate4sd3_1
X_9129_ clknet_leaf_103_CLK _0289_ VGND VGND VPWR VPWR regfile.registers\[28\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_723 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_72_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_72_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_112_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6830_ _3075_ net898 _3325_ VGND VGND VPWR VPWR _3331_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6761_ _3294_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8500_ net466 net33 _4227_ VGND VGND VPWR VPWR _4233_ sky130_fd_sc_hd__mux2_1
X_5712_ _1148_ _2368_ _2369_ _2464_ _2336_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__a311o_1
XFILLER_0_57_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6692_ _3073_ net1095 _3253_ VGND VGND VPWR VPWR _3258_ sky130_fd_sc_hd__mux2_1
X_9480_ clknet_leaf_87_CLK _0640_ VGND VGND VPWR VPWR regfile.registers\[16\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5643_ _1842_ _1798_ _1667_ VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__o21a_1
X_8431_ _4196_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_98_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8362_ net116 _3542_ _4155_ VGND VGND VPWR VPWR _4160_ sky130_fd_sc_hd__mux2_1
XFILLER_0_122_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5574_ _1666_ _2041_ _2103_ _2329_ VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__o22a_1
Xclkbuf_leaf_63_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_63_CLK sky130_fd_sc_hd__clkbuf_8
X_4525_ regfile.registers\[16\]\[26\] regfile.registers\[17\]\[26\] regfile.registers\[18\]\[26\]
+ regfile.registers\[19\]\[26\] _1181_ _1183_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__mux4_1
Xhold201 regfile.registers\[11\]\[16\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
X_7313_ _3046_ net1125 _3602_ VGND VGND VPWR VPWR _3604_ sky130_fd_sc_hd__mux2_1
X_8293_ _4123_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__clkbuf_1
Xhold223 regfile.registers\[6\]\[31\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold234 regfile.registers\[6\]\[7\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold212 regfile.registers\[2\]\[12\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4456_ _1209_ _1210_ _1211_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__mux2_1
Xhold256 regfile.registers\[21\]\[22\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold245 regfile.registers\[8\]\[19\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold278 regfile.registers\[9\]\[7\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
X_7244_ _3566_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
Xhold267 regfile.registers\[2\]\[10\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
X_7175_ net23 VGND VGND VPWR VPWR _3525_ sky130_fd_sc_hd__buf_2
X_4387_ _1088_ _1142_ net8 VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a21oi_1
Xhold289 regfile.registers\[0\]\[2\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
X_6126_ _2791_ _2858_ _2501_ VGND VGND VPWR VPWR _2859_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6057_ _2651_ _2731_ _2792_ _2496_ _2793_ VGND VGND VPWR VPWR _2794_ sky130_fd_sc_hd__a221o_1
X_5008_ _1762_ _1763_ _1726_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6959_ net693 _3137_ _3398_ VGND VGND VPWR VPWR _3400_ sky130_fd_sc_hd__mux2_1
XFILLER_0_119_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8629_ clknet_leaf_34_CLK _0813_ VGND VGND VPWR VPWR regfile.registers\[17\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_54_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_54_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_16_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold790 regfile.registers\[3\]\[19\] VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_110_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_45_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_45_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5290_ regfile.registers\[28\]\[3\] regfile.registers\[29\]\[3\] regfile.registers\[30\]\[3\]
+ regfile.registers\[31\]\[3\] _1674_ _1691_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__mux4_1
X_4310_ A2[1] VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8980_ clknet_leaf_16_CLK _0140_ VGND VGND VPWR VPWR regfile.registers\[7\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_7931_ _3931_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7862_ net219 _3519_ _3891_ VGND VGND VPWR VPWR _3895_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7793_ _3858_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__clkbuf_1
X_6813_ _3058_ net769 _3314_ VGND VGND VPWR VPWR _3322_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_102_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9532_ clknet_leaf_15_CLK _0692_ VGND VGND VPWR VPWR regfile.registers\[12\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6744_ _3285_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9463_ clknet_leaf_36_CLK _0623_ VGND VGND VPWR VPWR regfile.registers\[13\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_6675_ _3056_ net905 _3242_ VGND VGND VPWR VPWR _3249_ sky130_fd_sc_hd__mux2_1
X_5626_ _2379_ _2380_ VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__nor2_2
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8414_ _4187_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_36_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_36_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9394_ clknet_leaf_46_CLK _0554_ VGND VGND VPWR VPWR regfile.registers\[24\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5557_ _2311_ _2312_ _1684_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__mux2_1
X_8345_ net619 _3525_ _4144_ VGND VGND VPWR VPWR _4151_ sky130_fd_sc_hd__mux2_1
X_4508_ regfile.registers\[24\]\[21\] regfile.registers\[25\]\[21\] regfile.registers\[26\]\[21\]
+ regfile.registers\[27\]\[21\] _1262_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__mux4_2
X_5488_ _1712_ _2243_ _1716_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__o21a_1
X_8276_ _4114_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__clkbuf_1
X_4439_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__buf_4
X_7227_ _3557_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7158_ net892 _3512_ _3513_ VGND VGND VPWR VPWR _3514_ sky130_fd_sc_hd__mux2_1
X_6109_ _2806_ _2841_ _2842_ VGND VGND VPWR VPWR _2843_ sky130_fd_sc_hd__a21oi_1
X_7089_ net657 _3130_ _3460_ VGND VGND VPWR VPWR _3469_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_27_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_27_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_122_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4790_ regfile.registers\[28\]\[10\] regfile.registers\[29\]\[10\] regfile.registers\[30\]\[10\]
+ regfile.registers\[31\]\[10\] net86 _1043_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_18_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_18_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_55_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6460_ net467 _3128_ _3114_ VGND VGND VPWR VPWR _3129_ sky130_fd_sc_hd__mux2_1
X_6391_ net36 VGND VGND VPWR VPWR _3081_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_70_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5411_ regfile.registers\[8\]\[12\] regfile.registers\[9\]\[12\] regfile.registers\[10\]\[12\]
+ regfile.registers\[11\]\[12\] _2117_ _2118_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__mux4_1
X_5342_ _1638_ _2097_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__or2_1
X_8130_ _4037_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8061_ net137 _3512_ _4000_ VGND VGND VPWR VPWR _4001_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5273_ regfile.registers\[4\]\[24\] regfile.registers\[5\]\[24\] regfile.registers\[6\]\[24\]
+ regfile.registers\[7\]\[24\] _1918_ _1919_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__mux4_1
X_7012_ net843 _3122_ _3423_ VGND VGND VPWR VPWR _3428_ sky130_fd_sc_hd__mux2_1
X_8963_ clknet_leaf_89_CLK _0123_ VGND VGND VPWR VPWR regfile.registers\[7\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8894_ clknet_leaf_71_CLK _0054_ VGND VGND VPWR VPWR regfile.registers\[19\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_7914_ _3922_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_26_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7845_ net318 _3502_ _3880_ VGND VGND VPWR VPWR _3886_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4988_ _1740_ _1743_ _1697_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__mux2_1
X_7776_ _3849_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__clkbuf_1
X_9515_ clknet_leaf_99_CLK _0675_ VGND VGND VPWR VPWR regfile.registers\[12\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6727_ _3276_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9446_ clknet_leaf_68_CLK _0606_ VGND VGND VPWR VPWR regfile.registers\[13\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6658_ _3039_ net302 _3231_ VGND VGND VPWR VPWR _3240_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5609_ _2359_ _2362_ _2363_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__mux2_1
X_9377_ clknet_leaf_84_CLK _0537_ VGND VGND VPWR VPWR regfile.registers\[24\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_115_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6589_ net427 _3109_ _3194_ VGND VGND VPWR VPWR _3203_ sky130_fd_sc_hd__mux2_1
X_8328_ net282 _3508_ _4133_ VGND VGND VPWR VPWR _4142_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8259_ _4105_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_6_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 WD3[1] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput16 WD3[0] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_77_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput38 WD3[2] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
XFILLER_0_52_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_7_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_7_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_88_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5960_ _2421_ _2690_ _2691_ _2695_ _2702_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__o32a_1
XFILLER_0_59_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5891_ net1144 _2636_ VGND VGND VPWR VPWR _2637_ sky130_fd_sc_hd__xor2_1
X_4911_ _1171_ _1153_ _1157_ _1161_ _1165_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_75_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7630_ _3771_ VGND VGND VPWR VPWR _3772_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_74_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4842_ regfile.registers\[0\]\[17\] regfile.registers\[1\]\[17\] regfile.registers\[2\]\[17\]
+ regfile.registers\[3\]\[17\] _1181_ _1183_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__mux4_1
X_4773_ regfile.registers\[20\]\[9\] regfile.registers\[21\]\[9\] regfile.registers\[22\]\[9\]
+ regfile.registers\[23\]\[9\] _1290_ _1193_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__mux4_1
X_7561_ _3192_ _3589_ VGND VGND VPWR VPWR _3735_ sky130_fd_sc_hd__nand2b_4
X_9300_ clknet_leaf_26_CLK _0460_ VGND VGND VPWR VPWR regfile.registers\[25\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_7492_ _3698_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
X_6512_ _3033_ net1088 _3155_ VGND VGND VPWR VPWR _3161_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6443_ _3117_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_31_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9231_ clknet_leaf_1_CLK _0391_ VGND VGND VPWR VPWR regfile.registers\[9\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6374_ _3069_ net979 _3065_ VGND VGND VPWR VPWR _3070_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9162_ clknet_leaf_8_CLK _0322_ VGND VGND VPWR VPWR regfile.registers\[2\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_5325_ _1638_ _2080_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__nor2_1
X_8113_ _4028_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__clkbuf_1
X_9093_ clknet_leaf_65_CLK _0253_ VGND VGND VPWR VPWR regfile.registers\[27\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_5256_ regfile.registers\[0\]\[25\] regfile.registers\[1\]\[25\] regfile.registers\[2\]\[25\]
+ regfile.registers\[3\]\[25\] _1767_ _1768_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8044_ net1090 _3496_ _3989_ VGND VGND VPWR VPWR _3992_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_110_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5187_ _1638_ _1942_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_3_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8946_ clknet_leaf_47_CLK _0106_ VGND VGND VPWR VPWR regfile.registers\[3\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8877_ clknet_leaf_94_CLK _0037_ VGND VGND VPWR VPWR regfile.registers\[4\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7828_ _3876_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7759_ _3083_ net989 _3830_ VGND VGND VPWR VPWR _3840_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9429_ clknet_leaf_32_CLK _0589_ VGND VGND VPWR VPWR regfile.registers\[1\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold608 regfile.registers\[31\]\[18\] VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold619 regfile.registers\[0\]\[4\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6090_ _2102_ _2523_ VGND VGND VPWR VPWR _2825_ sky130_fd_sc_hd__nor2_1
X_5110_ regfile.registers\[8\]\[16\] regfile.registers\[9\]\[16\] regfile.registers\[10\]\[16\]
+ regfile.registers\[11\]\[16\] _1720_ _1723_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__mux4_1
X_5041_ _1791_ _1793_ _1796_ _1697_ _1671_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__o221a_1
XFILLER_0_109_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8800_ clknet_leaf_74_CLK _0984_ VGND VGND VPWR VPWR regfile.registers\[6\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_8731_ clknet_leaf_39_CLK _0915_ VGND VGND VPWR VPWR regfile.registers\[15\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6992_ _3417_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_5943_ net1143 _2536_ _2685_ _2683_ VGND VGND VPWR VPWR _2686_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_36_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8662_ clknet_leaf_52_CLK _0846_ VGND VGND VPWR VPWR regfile.registers\[22\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_5874_ _2333_ VGND VGND VPWR VPWR _2621_ sky130_fd_sc_hd__buf_2
XFILLER_0_8_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7613_ _3073_ net717 _3758_ VGND VGND VPWR VPWR _3763_ sky130_fd_sc_hd__mux2_1
X_8593_ clknet_leaf_18_CLK _0777_ VGND VGND VPWR VPWR regfile.registers\[23\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_4825_ _1579_ _1580_ _1287_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_16_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7544_ _3726_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_118_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone19 net100 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_16
X_4756_ _1495_ _1511_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__and2_4
XFILLER_0_43_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7475_ _3071_ net941 _3686_ VGND VGND VPWR VPWR _3690_ sky130_fd_sc_hd__mux2_1
X_4687_ regfile.registers\[0\]\[22\] regfile.registers\[1\]\[22\] regfile.registers\[2\]\[22\]
+ regfile.registers\[3\]\[22\] _1173_ _1175_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6426_ net635 _3105_ _3093_ VGND VGND VPWR VPWR _3106_ sky130_fd_sc_hd__mux2_1
X_9214_ clknet_leaf_66_CLK _0374_ VGND VGND VPWR VPWR regfile.registers\[9\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_9145_ clknet_leaf_35_CLK _0305_ VGND VGND VPWR VPWR regfile.registers\[28\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6357_ net24 VGND VGND VPWR VPWR _3058_ sky130_fd_sc_hd__clkbuf_2
X_5308_ _1167_ _2063_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__or2_1
X_6288_ _3010_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__clkbuf_1
X_9076_ clknet_leaf_22_CLK _0236_ VGND VGND VPWR VPWR regfile.registers\[26\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_8027_ _3009_ net271 _3974_ VGND VGND VPWR VPWR _3982_ sky130_fd_sc_hd__mux2_1
X_5239_ _1773_ _1990_ _1992_ _1994_ _1672_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_123_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8929_ clknet_leaf_65_CLK _0089_ VGND VGND VPWR VPWR regfile.registers\[3\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4610_ regfile.registers\[4\]\[25\] regfile.registers\[5\]\[25\] regfile.registers\[6\]\[25\]
+ regfile.registers\[7\]\[25\] _1360_ _1361_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__mux4_1
XFILLER_0_72_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5590_ _2144_ _2160_ _1668_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__a21o_1
X_4541_ _1289_ _1293_ _1296_ _1205_ _1025_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__o221a_1
XFILLER_0_4_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4472_ _1224_ _1227_ _1187_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_96_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold427 regfile.registers\[1\]\[31\] VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlygate4sd3_1
X_7260_ _3574_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
Xhold416 regfile.registers\[21\]\[5\] VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold405 regfile.registers\[13\]\[11\] VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlygate4sd3_1
X_7191_ net29 VGND VGND VPWR VPWR _3536_ sky130_fd_sc_hd__buf_2
XFILLER_0_111_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6211_ _2891_ _2937_ _2935_ _2938_ _2916_ VGND VGND VPWR VPWR _2939_ sky130_fd_sc_hd__o311a_1
Xhold449 regfile.registers\[19\]\[0\] VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold438 regfile.registers\[11\]\[14\] VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__dlygate4sd3_1
X_6142_ _1384_ _2873_ VGND VGND VPWR VPWR _2874_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6073_ _2769_ _2784_ VGND VGND VPWR VPWR _2809_ sky130_fd_sc_hd__or2_1
X_5024_ _1758_ _1779_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6975_ net697 _3013_ _3398_ VGND VGND VPWR VPWR _3408_ sky130_fd_sc_hd__mux2_1
X_5926_ _2663_ _2668_ VGND VGND VPWR VPWR _2670_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8714_ clknet_leaf_106_CLK _0898_ VGND VGND VPWR VPWR regfile.registers\[15\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_105_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8645_ clknet_leaf_67_CLK _0829_ VGND VGND VPWR VPWR regfile.registers\[22\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_5857_ _2390_ _2590_ VGND VGND VPWR VPWR _2604_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5788_ net1138 _2537_ VGND VGND VPWR VPWR _2538_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8576_ clknet_leaf_77_CLK _0760_ VGND VGND VPWR VPWR regfile.registers\[23\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_4808_ regfile.registers\[8\]\[11\] regfile.registers\[9\]\[11\] regfile.registers\[10\]\[11\]
+ regfile.registers\[11\]\[11\] net98 _1053_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux4_1
X_4739_ _1464_ _1480_ _1494_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7527_ _3717_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7458_ _3054_ net986 _3675_ VGND VGND VPWR VPWR _3681_ sky130_fd_sc_hd__mux2_1
X_6409_ _3094_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold961 regfile.registers\[29\]\[26\] VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__dlygate4sd3_1
Xhold972 regfile.registers\[14\]\[19\] VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold950 regfile.registers\[18\]\[1\] VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__dlygate4sd3_1
X_7389_ _3054_ net882 _3638_ VGND VGND VPWR VPWR _3644_ sky130_fd_sc_hd__mux2_1
Xhold994 regfile.registers\[28\]\[9\] VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__dlygate4sd3_1
X_9128_ clknet_leaf_102_CLK _0288_ VGND VGND VPWR VPWR regfile.registers\[28\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold983 regfile.registers\[15\]\[17\] VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__dlygate4sd3_1
X_9059_ clknet_leaf_80_CLK _0219_ VGND VGND VPWR VPWR regfile.registers\[26\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_735 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6760_ net464 _3143_ _3289_ VGND VGND VPWR VPWR _3294_ sky130_fd_sc_hd__mux2_1
X_5711_ _2178_ _2362_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6691_ _3257_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_127_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5642_ _2393_ _2396_ _1146_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__mux2_1
X_8430_ net818 _3542_ _4191_ VGND VGND VPWR VPWR _4196_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8361_ _4159_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__clkbuf_1
X_5573_ _2105_ _2253_ _2255_ _2328_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4524_ regfile.registers\[20\]\[26\] regfile.registers\[21\]\[26\] regfile.registers\[22\]\[26\]
+ regfile.registers\[23\]\[26\] _1172_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__mux4_1
Xhold202 regfile.registers\[16\]\[8\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7312_ _3603_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
X_8292_ _3141_ net705 _4119_ VGND VGND VPWR VPWR _4123_ sky130_fd_sc_hd__mux2_1
Xhold224 regfile.registers\[10\]\[31\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold235 regfile.registers\[14\]\[8\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 regfile.registers\[1\]\[3\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold268 regfile.registers\[13\]\[20\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
X_4455_ _1198_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__buf_4
Xhold257 regfile.registers\[19\]\[16\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
Xhold246 regfile.registers\[24\]\[5\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7243_ net606 _3515_ _3564_ VGND VGND VPWR VPWR _3566_ sky130_fd_sc_hd__mux2_1
Xhold279 regfile.registers\[13\]\[8\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
X_7174_ _3524_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
X_4386_ _1140_ _1141_ _1107_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__mux2_1
X_6125_ _2820_ _2857_ _1147_ VGND VGND VPWR VPWR _2858_ sky130_fd_sc_hd__mux2_1
X_6056_ _2458_ _2738_ VGND VGND VPWR VPWR _2793_ sky130_fd_sc_hd__nor2_1
X_5007_ regfile.registers\[24\]\[21\] regfile.registers\[25\]\[21\] regfile.registers\[26\]\[21\]
+ regfile.registers\[27\]\[21\] _1676_ _1681_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_107_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6958_ _3399_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5909_ _2468_ _2530_ _2475_ _2503_ VGND VGND VPWR VPWR _2654_ sky130_fd_sc_hd__a31o_1
X_6889_ net484 _3134_ _3362_ VGND VGND VPWR VPWR _3363_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8628_ clknet_leaf_23_CLK _0812_ VGND VGND VPWR VPWR regfile.registers\[17\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8559_ _4263_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_106_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold780 regfile.registers\[8\]\[23\] VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold791 regfile.registers\[18\]\[2\] VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7930_ _3120_ net633 _3927_ VGND VGND VPWR VPWR _3931_ sky130_fd_sc_hd__mux2_1
X_7861_ _3894_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6812_ _3321_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7792_ net173 _3517_ _3855_ VGND VGND VPWR VPWR _3858_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_102_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9531_ clknet_leaf_38_CLK _0691_ VGND VGND VPWR VPWR regfile.registers\[12\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_6743_ net763 _3126_ _3278_ VGND VGND VPWR VPWR _3285_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9462_ clknet_leaf_48_CLK _0622_ VGND VGND VPWR VPWR regfile.registers\[13\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6674_ _3248_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5625_ _1167_ _1943_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8413_ net431 _3525_ _4180_ VGND VGND VPWR VPWR _4187_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9393_ clknet_leaf_6_CLK _0553_ VGND VGND VPWR VPWR regfile.registers\[24\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8344_ _4150_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5556_ regfile.registers\[24\]\[5\] regfile.registers\[25\]\[5\] regfile.registers\[26\]\[5\]
+ regfile.registers\[27\]\[5\] _1702_ _1678_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5487_ regfile.registers\[0\]\[9\] regfile.registers\[1\]\[9\] regfile.registers\[2\]\[9\]
+ regfile.registers\[3\]\[9\] _1719_ _1722_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__mux4_1
X_4507_ _1221_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__buf_4
XFILLER_0_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8275_ _3124_ net458 _4108_ VGND VGND VPWR VPWR _4114_ sky130_fd_sc_hd__mux2_1
X_4438_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__clkbuf_8
X_7226_ net627 _3498_ _3553_ VGND VGND VPWR VPWR _3557_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7157_ _3491_ VGND VGND VPWR VPWR _3513_ sky130_fd_sc_hd__buf_4
X_4369_ _1024_ _1116_ _1124_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__o21ai_4
X_6108_ _1779_ _2829_ VGND VGND VPWR VPWR _2842_ sky130_fd_sc_hd__and2b_1
X_7088_ _3468_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_6039_ _1669_ _1821_ _1860_ VGND VGND VPWR VPWR _2777_ sky130_fd_sc_hd__o21a_1
XFILLER_0_68_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6390_ _3080_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_112_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5410_ _2162_ _2163_ _2164_ _2165_ _1711_ _1716_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__mux4_1
X_5341_ _1640_ _2088_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__o21ai_2
X_8060_ _3988_ VGND VGND VPWR VPWR _4000_ sky130_fd_sc_hd__buf_6
X_5272_ _1901_ _2027_ _1717_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7011_ _3427_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_128_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8962_ clknet_leaf_88_CLK _0122_ VGND VGND VPWR VPWR regfile.registers\[7\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_7913_ _3103_ net1062 _3916_ VGND VGND VPWR VPWR _3922_ sky130_fd_sc_hd__mux2_1
X_8893_ clknet_leaf_44_CLK _0053_ VGND VGND VPWR VPWR regfile.registers\[4\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7844_ _3885_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__clkbuf_1
X_7775_ net268 _3500_ _3844_ VGND VGND VPWR VPWR _3849_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4987_ _1741_ _1742_ _1739_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__mux2_1
X_6726_ net602 _3109_ _3267_ VGND VGND VPWR VPWR _3276_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9514_ clknet_leaf_106_CLK _0674_ VGND VGND VPWR VPWR regfile.registers\[12\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6657_ _3239_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__clkbuf_1
X_9445_ clknet_leaf_66_CLK _0605_ VGND VGND VPWR VPWR regfile.registers\[13\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5608_ _1877_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_104_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6588_ _3202_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9376_ clknet_leaf_78_CLK _0536_ VGND VGND VPWR VPWR regfile.registers\[24\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_115_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8327_ _4141_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__clkbuf_1
X_5539_ _2293_ _2294_ _2044_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8258_ _3107_ net1086 _4097_ VGND VGND VPWR VPWR _4105_ sky130_fd_sc_hd__mux2_1
X_7209_ _3547_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
X_8189_ _4068_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_6_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput28 WD3[20] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_107_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput17 WD3[10] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
XFILLER_0_25_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput39 WD3[30] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_77_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4910_ _1665_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__buf_2
X_5890_ _2598_ _2618_ _2617_ _2635_ VGND VGND VPWR VPWR _2636_ sky130_fd_sc_hd__a31o_1
X_4841_ regfile.registers\[4\]\[17\] regfile.registers\[5\]\[17\] regfile.registers\[6\]\[17\]
+ regfile.registers\[7\]\[17\] _1181_ _1183_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__mux4_1
XFILLER_0_74_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7560_ _3734_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
X_4772_ _1025_ _1519_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__o21a_4
XFILLER_0_99_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7491_ _3087_ net982 _3663_ VGND VGND VPWR VPWR _3698_ sky130_fd_sc_hd__mux2_1
X_6511_ _3160_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9230_ clknet_leaf_21_CLK _0390_ VGND VGND VPWR VPWR regfile.registers\[9\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6442_ net236 _3116_ _3114_ VGND VGND VPWR VPWR _3117_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9161_ clknet_leaf_97_CLK _0321_ VGND VGND VPWR VPWR regfile.registers\[2\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_6373_ net30 VGND VGND VPWR VPWR _3069_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8112_ net648 _3496_ _4025_ VGND VGND VPWR VPWR _4028_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5324_ net5 _2071_ _2079_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__a21oi_2
X_9092_ clknet_leaf_92_CLK _0252_ VGND VGND VPWR VPWR regfile.registers\[27\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_5255_ regfile.registers\[4\]\[25\] regfile.registers\[5\]\[25\] regfile.registers\[6\]\[25\]
+ regfile.registers\[7\]\[25\] _1895_ _1897_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__mux4_1
X_8043_ _3991_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_110_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5186_ _1777_ _1933_ _1941_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_3_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8945_ clknet_leaf_18_CLK _0105_ VGND VGND VPWR VPWR regfile.registers\[3\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_8876_ clknet_leaf_106_CLK _0036_ VGND VGND VPWR VPWR regfile.registers\[4\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7827_ net377 _3484_ _3866_ VGND VGND VPWR VPWR _3876_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7758_ _3839_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_50_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7689_ net381 _3482_ _3794_ VGND VGND VPWR VPWR _3803_ sky130_fd_sc_hd__mux2_1
X_6709_ _3266_ VGND VGND VPWR VPWR _3267_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9428_ clknet_leaf_16_CLK _0588_ VGND VGND VPWR VPWR regfile.registers\[1\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9359_ clknet_leaf_2_CLK _0519_ VGND VGND VPWR VPWR regfile.registers\[20\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_72_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_123_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold609 regfile.registers\[23\]\[7\] VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_2__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_2__leaf_CLK sky130_fd_sc_hd__clkbuf_16
X_5040_ _1794_ _1795_ _1739_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6991_ net597 _3101_ _3412_ VGND VGND VPWR VPWR _3417_ sky130_fd_sc_hd__mux2_1
X_8730_ clknet_leaf_23_CLK _0914_ VGND VGND VPWR VPWR regfile.registers\[15\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_5942_ net1148 _2411_ VGND VGND VPWR VPWR _2685_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_36_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8661_ clknet_leaf_29_CLK _0845_ VGND VGND VPWR VPWR regfile.registers\[22\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_5873_ _2617_ _2619_ VGND VGND VPWR VPWR _2620_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7612_ _3762_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
X_4824_ regfile.registers\[12\]\[16\] regfile.registers\[13\]\[16\] regfile.registers\[14\]\[16\]
+ regfile.registers\[15\]\[16\] _1191_ _1174_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_16_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8592_ clknet_leaf_9_CLK _0776_ VGND VGND VPWR VPWR regfile.registers\[23\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_7543_ _3071_ net1039 _3722_ VGND VGND VPWR VPWR _3726_ sky130_fd_sc_hd__mux2_1
X_4755_ _1239_ _1502_ _1506_ _1510_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_8_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7474_ _3689_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
X_4686_ regfile.registers\[4\]\[22\] regfile.registers\[5\]\[22\] regfile.registers\[6\]\[22\]
+ regfile.registers\[7\]\[22\] _1173_ _1175_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__mux4_1
X_9213_ clknet_leaf_11_CLK _0373_ VGND VGND VPWR VPWR regfile.registers\[30\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6425_ net44 VGND VGND VPWR VPWR _3105_ sky130_fd_sc_hd__buf_2
X_9144_ clknet_leaf_21_CLK _0304_ VGND VGND VPWR VPWR regfile.registers\[28\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_6356_ _3057_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9075_ clknet_leaf_27_CLK _0235_ VGND VGND VPWR VPWR regfile.registers\[26\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5307_ _1638_ _2062_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__or2_1
X_6287_ net378 _3009_ _3007_ VGND VGND VPWR VPWR _3010_ sky130_fd_sc_hd__mux2_1
X_8026_ _3981_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__clkbuf_1
X_5238_ _1901_ _1993_ _1766_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__a21o_1
X_5169_ _1169_ _1924_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_123_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8928_ clknet_leaf_77_CLK _0088_ VGND VGND VPWR VPWR regfile.registers\[3\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8859_ clknet_leaf_42_CLK _0019_ VGND VGND VPWR VPWR regfile.registers\[5\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4540_ _1294_ _1295_ _1287_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4471_ _1225_ _1226_ _1178_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold417 regfile.registers\[7\]\[4\] VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlygate4sd3_1
Xhold406 regfile.registers\[29\]\[18\] VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__dlygate4sd3_1
X_6210_ _1996_ _2903_ _2917_ VGND VGND VPWR VPWR _2938_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_96_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7190_ _3535_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
Xhold428 regfile.registers\[17\]\[26\] VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold439 regfile.registers\[18\]\[16\] VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__dlygate4sd3_1
X_6141_ _2595_ _2872_ VGND VGND VPWR VPWR _2873_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6072_ _2806_ _2807_ VGND VGND VPWR VPWR _2808_ sky130_fd_sc_hd__or2_1
X_5023_ _1672_ _1765_ _1772_ _1778_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__a2bb2o_2
X_6974_ _3407_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
X_5925_ _2663_ _2668_ VGND VGND VPWR VPWR _2669_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8713_ clknet_leaf_99_CLK _0897_ VGND VGND VPWR VPWR regfile.registers\[15\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_105_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5856_ _2587_ _2589_ _2592_ _2603_ _2408_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__o32a_1
XFILLER_0_76_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8644_ clknet_leaf_92_CLK _0828_ VGND VGND VPWR VPWR regfile.registers\[22\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4807_ _1559_ _1560_ _1561_ _1562_ _1048_ _1050_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__mux4_2
X_5787_ net83 _2535_ _2536_ VGND VGND VPWR VPWR _2537_ sky130_fd_sc_hd__a21oi_1
X_8575_ clknet_leaf_79_CLK _0759_ VGND VGND VPWR VPWR regfile.registers\[23\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4738_ _1215_ _1485_ _1493_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__o21ai_4
X_7526_ _3054_ net908 _3711_ VGND VGND VPWR VPWR _3717_ sky130_fd_sc_hd__mux2_1
X_4669_ _1214_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__nand2_1
X_7457_ _3680_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_102_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold940 regfile.registers\[15\]\[1\] VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__dlygate4sd3_1
X_6408_ net181 _3089_ _3093_ VGND VGND VPWR VPWR _3094_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9127_ clknet_leaf_62_CLK _0287_ VGND VGND VPWR VPWR regfile.registers\[28\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold962 regfile.registers\[28\]\[12\] VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__dlygate4sd3_1
X_7388_ _3643_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
Xhold973 regfile.registers\[12\]\[11\] VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__dlygate4sd3_1
Xhold951 regfile.registers\[30\]\[6\] VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold984 regfile.registers\[5\]\[31\] VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__dlygate4sd3_1
X_6339_ net18 VGND VGND VPWR VPWR _3046_ sky130_fd_sc_hd__clkbuf_2
Xhold995 regfile.registers\[15\]\[14\] VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__dlygate4sd3_1
X_9058_ clknet_leaf_86_CLK _0218_ VGND VGND VPWR VPWR regfile.registers\[26\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_8009_ _3972_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5710_ _2354_ _2359_ _2178_ VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6690_ _3071_ net923 _3253_ VGND VGND VPWR VPWR _3257_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5641_ _2394_ _2395_ VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_98_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8360_ net222 _3540_ _4155_ VGND VGND VPWR VPWR _4159_ sky130_fd_sc_hd__mux2_1
X_5572_ _2289_ _2326_ _2327_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__mux2_1
X_8291_ _4122_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7311_ _3043_ net835 _3602_ VGND VGND VPWR VPWR _3603_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4523_ _1073_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__buf_4
Xhold214 regfile.registers\[17\]\[23\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
Xhold225 regfile.registers\[10\]\[9\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold203 regfile.registers\[10\]\[5\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
X_7242_ _3565_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
Xhold258 regfile.registers\[6\]\[24\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
X_4454_ regfile.registers\[0\]\[29\] regfile.registers\[1\]\[29\] regfile.registers\[2\]\[29\]
+ regfile.registers\[3\]\[29\] _1207_ _1208_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__mux4_1
Xhold247 regfile.registers\[10\]\[20\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold236 regfile.registers\[8\]\[10\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold269 regfile.registers\[3\]\[4\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4385_ regfile.registers\[0\]\[1\] regfile.registers\[1\]\[1\] regfile.registers\[2\]\[1\]
+ regfile.registers\[3\]\[1\] net99 _1090_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__mux4_1
X_7173_ net160 _3523_ _3513_ VGND VGND VPWR VPWR _3524_ sky130_fd_sc_hd__mux2_1
X_6124_ _2394_ _2392_ VGND VGND VPWR VPWR _2857_ sky130_fd_sc_hd__nor2_1
X_6055_ _2718_ _2791_ _2501_ VGND VGND VPWR VPWR _2792_ sky130_fd_sc_hd__mux2_1
X_5006_ regfile.registers\[28\]\[21\] regfile.registers\[29\]\[21\] regfile.registers\[30\]\[21\]
+ regfile.registers\[31\]\[21\] _1676_ _1681_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_107_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6957_ net135 _3134_ _3398_ VGND VGND VPWR VPWR _3399_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_120_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5908_ _1087_ _2652_ VGND VGND VPWR VPWR _2653_ sky130_fd_sc_hd__and2_1
X_6888_ _3339_ VGND VGND VPWR VPWR _3362_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8627_ clknet_leaf_28_CLK _0811_ VGND VGND VPWR VPWR regfile.registers\[17\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_119_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5839_ _2335_ _2586_ VGND VGND VPWR VPWR _2587_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8558_ net351 net29 _4255_ VGND VGND VPWR VPWR _4263_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7509_ _3037_ net912 _3700_ VGND VGND VPWR VPWR _3708_ sky130_fd_sc_hd__mux2_1
XFILLER_0_121_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8489_ _4204_ VGND VGND VPWR VPWR _4227_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_15_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold770 regfile.registers\[14\]\[3\] VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold781 regfile.registers\[20\]\[6\] VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__dlygate4sd3_1
Xhold792 regfile.registers\[0\]\[13\] VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_42_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7860_ net234 _3517_ _3891_ VGND VGND VPWR VPWR _3894_ sky130_fd_sc_hd__mux2_1
X_6811_ _3056_ net807 _3314_ VGND VGND VPWR VPWR _3321_ sky130_fd_sc_hd__mux2_1
X_7791_ _3857_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_102_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9530_ clknet_leaf_24_CLK _0690_ VGND VGND VPWR VPWR regfile.registers\[12\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6742_ _3284_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9461_ clknet_leaf_30_CLK _0621_ VGND VGND VPWR VPWR regfile.registers\[13\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_6673_ _3054_ net846 _3242_ VGND VGND VPWR VPWR _3248_ sky130_fd_sc_hd__mux2_1
X_5624_ _1799_ _1924_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__nor2_2
X_8412_ _4186_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9392_ clknet_leaf_9_CLK _0552_ VGND VGND VPWR VPWR regfile.registers\[24\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8343_ net828 _3523_ _4144_ VGND VGND VPWR VPWR _4150_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5555_ regfile.registers\[28\]\[5\] regfile.registers\[29\]\[5\] regfile.registers\[30\]\[5\]
+ regfile.registers\[31\]\[5\] _2050_ _1678_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__mux4_1
XFILLER_0_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5486_ _1739_ _2241_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__or2_1
X_4506_ _1219_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__buf_12
X_8274_ _4113_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__clkbuf_1
X_4437_ _1066_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__clkbuf_4
X_7225_ _3556_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
X_7156_ net17 VGND VGND VPWR VPWR _3512_ sky130_fd_sc_hd__buf_2
X_6107_ _2829_ _1779_ VGND VGND VPWR VPWR _2841_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_60_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4368_ _1118_ _1120_ _1123_ _1037_ net8 VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__a221o_1
X_4299_ regfile.registers\[12\]\[4\] regfile.registers\[13\]\[4\] regfile.registers\[14\]\[4\]
+ regfile.registers\[15\]\[4\] _1052_ _1053_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__mux4_1
X_7087_ net387 _3128_ _3460_ VGND VGND VPWR VPWR _3468_ sky130_fd_sc_hd__mux2_1
X_6038_ _2102_ _2445_ VGND VGND VPWR VPWR _2776_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer40 net1148 VGND VGND VPWR VPWR net1149 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_96_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7989_ _3111_ net570 _3952_ VGND VGND VPWR VPWR _3962_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_104_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_104_CLK
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_9_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5340_ _2090_ _2092_ _2095_ net4 net5 VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__a221o_1
XFILLER_0_121_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5271_ regfile.registers\[8\]\[24\] regfile.registers\[9\]\[24\] regfile.registers\[10\]\[24\]
+ regfile.registers\[11\]\[24\] _1881_ _1883_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__mux4_1
X_7010_ net857 _3120_ _3423_ VGND VGND VPWR VPWR _3427_ sky130_fd_sc_hd__mux2_1
XFILLER_0_128_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8961_ clknet_leaf_90_CLK _0121_ VGND VGND VPWR VPWR regfile.registers\[7\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_7912_ _3921_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__clkbuf_1
X_8892_ clknet_leaf_44_CLK _0052_ VGND VGND VPWR VPWR regfile.registers\[4\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_7843_ net669 _3500_ _3880_ VGND VGND VPWR VPWR _3885_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4986_ regfile.registers\[24\]\[22\] regfile.registers\[25\]\[22\] regfile.registers\[26\]\[22\]
+ regfile.registers\[27\]\[22\] _1734_ _1735_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__mux4_1
X_7774_ _3848_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6725_ _3275_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__clkbuf_1
X_9513_ clknet_leaf_99_CLK _0673_ VGND VGND VPWR VPWR regfile.registers\[12\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9444_ clknet_leaf_91_CLK _0604_ VGND VGND VPWR VPWR regfile.registers\[13\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_6656_ _3037_ net651 _3231_ VGND VGND VPWR VPWR _3239_ sky130_fd_sc_hd__mux2_1
X_5607_ _2360_ _2361_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9375_ clknet_leaf_80_CLK _0535_ VGND VGND VPWR VPWR regfile.registers\[24\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_6587_ net1061 _3107_ _3194_ VGND VGND VPWR VPWR _3202_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_115_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5538_ regfile.registers\[24\]\[4\] regfile.registers\[25\]\[4\] regfile.registers\[26\]\[4\]
+ regfile.registers\[27\]\[4\] _2050_ _2052_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__mux4_1
X_8326_ net612 _3506_ _4133_ VGND VGND VPWR VPWR _4141_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8257_ _4104_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7208_ net118 _3480_ _3534_ VGND VGND VPWR VPWR _3547_ sky130_fd_sc_hd__mux2_1
X_5469_ regfile.registers\[4\]\[8\] regfile.registers\[5\]\[8\] regfile.registers\[6\]\[8\]
+ regfile.registers\[7\]\[8\] _1734_ _1735_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8188_ net803 _3504_ _4061_ VGND VGND VPWR VPWR _4068_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_6_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7139_ net349 _3500_ _3492_ VGND VGND VPWR VPWR _3501_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_126_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 WD3[11] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_37_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput29 WD3[21] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_77_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4840_ _1213_ _1595_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4771_ _1521_ _1523_ _1526_ _1050_ net8 VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__a221o_1
XFILLER_0_7_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6510_ _3031_ net506 _3155_ VGND VGND VPWR VPWR _3160_ sky130_fd_sc_hd__mux2_1
X_7490_ _3697_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
X_6441_ net18 VGND VGND VPWR VPWR _3116_ sky130_fd_sc_hd__buf_2
X_6372_ _3068_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9160_ clknet_leaf_96_CLK _0320_ VGND VGND VPWR VPWR regfile.registers\[2\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_8111_ _4027_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5323_ _2073_ _2075_ _2078_ net4 _1640_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__o221a_1
X_9091_ clknet_leaf_80_CLK _0251_ VGND VGND VPWR VPWR regfile.registers\[27\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
X_5254_ _1773_ _2009_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__nor2_1
X_8042_ net710 _3494_ _3989_ VGND VGND VPWR VPWR _3991_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_110_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5185_ _1935_ _1937_ _1940_ _1773_ _1671_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_3_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8944_ clknet_leaf_10_CLK _0104_ VGND VGND VPWR VPWR regfile.registers\[3\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8875_ clknet_leaf_97_CLK _0035_ VGND VGND VPWR VPWR regfile.registers\[4\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_7826_ _3875_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4969_ regfile.registers\[0\]\[23\] regfile.registers\[1\]\[23\] regfile.registers\[2\]\[23\]
+ regfile.registers\[3\]\[23\] _1720_ _1723_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__mux4_1
X_7757_ _3081_ net718 _3830_ VGND VGND VPWR VPWR _3839_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7688_ _3802_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6708_ _3003_ _3192_ VGND VGND VPWR VPWR _3266_ sky130_fd_sc_hd__nor2_2
XFILLER_0_34_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9427_ clknet_leaf_33_CLK _0587_ VGND VGND VPWR VPWR regfile.registers\[1\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_6639_ net13 net12 net11 VGND VGND VPWR VPWR _3229_ sky130_fd_sc_hd__and3b_2
X_9358_ clknet_leaf_4_CLK _0518_ VGND VGND VPWR VPWR regfile.registers\[20\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_8309_ _4131_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__clkbuf_1
X_9289_ clknet_leaf_101_CLK _0449_ VGND VGND VPWR VPWR regfile.registers\[25\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_72_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6990_ _3416_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
X_5941_ _1464_ net104 _2411_ _2683_ VGND VGND VPWR VPWR _2684_ sky130_fd_sc_hd__a211o_1
XFILLER_0_87_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8660_ clknet_leaf_22_CLK _0844_ VGND VGND VPWR VPWR regfile.registers\[22\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_5872_ _2229_ _2597_ _2598_ _2618_ VGND VGND VPWR VPWR _2619_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7611_ _3071_ net1066 _3758_ VGND VGND VPWR VPWR _3762_ sky130_fd_sc_hd__mux2_1
X_4823_ regfile.registers\[8\]\[16\] regfile.registers\[9\]\[16\] regfile.registers\[10\]\[16\]
+ regfile.registers\[11\]\[16\] _1191_ _1174_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8591_ clknet_leaf_2_CLK _0775_ VGND VGND VPWR VPWR regfile.registers\[23\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_7542_ _3725_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
X_4754_ _1254_ _1509_ _1170_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_16_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_93_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_93_CLK sky130_fd_sc_hd__clkbuf_8
X_7473_ _3069_ net1023 _3686_ VGND VGND VPWR VPWR _3689_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4685_ _1199_ _1440_ _1213_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__o21a_1
X_9212_ clknet_leaf_41_CLK _0372_ VGND VGND VPWR VPWR regfile.registers\[30\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6424_ _3104_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__clkbuf_1
X_9143_ clknet_leaf_34_CLK _0303_ VGND VGND VPWR VPWR regfile.registers\[28\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6355_ _3056_ net919 _3044_ VGND VGND VPWR VPWR _3057_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_58_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6286_ net35 VGND VGND VPWR VPWR _3009_ sky130_fd_sc_hd__buf_2
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9074_ clknet_leaf_46_CLK _0234_ VGND VGND VPWR VPWR regfile.registers\[26\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_5306_ _1729_ _2049_ _2057_ _2061_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__o2bb2a_2
X_5237_ regfile.registers\[0\]\[26\] regfile.registers\[1\]\[26\] regfile.registers\[2\]\[26\]
+ regfile.registers\[3\]\[26\] _1896_ _1898_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__mux4_1
X_8025_ _3002_ net631 _3974_ VGND VGND VPWR VPWR _3981_ sky130_fd_sc_hd__mux2_1
X_5168_ _1639_ _1923_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__or2_1
X_5099_ regfile.registers\[0\]\[17\] regfile.registers\[1\]\[17\] regfile.registers\[2\]\[17\]
+ regfile.registers\[3\]\[17\] _1822_ _1823_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__mux4_1
X_8927_ clknet_leaf_75_CLK _0087_ VGND VGND VPWR VPWR regfile.registers\[3\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_123_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8858_ clknet_leaf_39_CLK _0018_ VGND VGND VPWR VPWR regfile.registers\[5\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8789_ clknet_leaf_30_CLK _0973_ VGND VGND VPWR VPWR regfile.registers\[14\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_7809_ net477 _3533_ _3866_ VGND VGND VPWR VPWR _3867_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_84_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_84_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_75_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_75_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4470_ regfile.registers\[24\]\[28\] regfile.registers\[25\]\[28\] regfile.registers\[26\]\[28\]
+ regfile.registers\[27\]\[28\] _1220_ _1222_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_96_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold407 regfile.registers\[2\]\[30\] VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold418 regfile.registers\[16\]\[18\] VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_123_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold429 regfile.registers\[31\]\[8\] VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd3_1
X_6140_ _1447_ _2871_ VGND VGND VPWR VPWR _2872_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6071_ _1798_ _2805_ VGND VGND VPWR VPWR _2807_ sky130_fd_sc_hd__and2_1
X_5022_ _1773_ _1776_ _1777_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6973_ net266 _3011_ _3398_ VGND VGND VPWR VPWR _3407_ sky130_fd_sc_hd__mux2_1
X_5924_ _2602_ _2665_ _2667_ VGND VGND VPWR VPWR _2668_ sky130_fd_sc_hd__o21a_1
XFILLER_0_76_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8712_ clknet_leaf_100_CLK _0896_ VGND VGND VPWR VPWR regfile.registers\[15\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_105_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5855_ _2598_ _2602_ VGND VGND VPWR VPWR _2603_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8643_ clknet_leaf_84_CLK _0827_ VGND VGND VPWR VPWR regfile.registers\[22\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4806_ regfile.registers\[20\]\[11\] regfile.registers\[21\]\[11\] regfile.registers\[22\]\[11\]
+ regfile.registers\[23\]\[11\] _1072_ _1073_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__mux4_1
X_5786_ _2411_ VGND VGND VPWR VPWR _2536_ sky130_fd_sc_hd__buf_2
XFILLER_0_28_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8574_ clknet_leaf_72_CLK _0758_ VGND VGND VPWR VPWR regfile.registers\[23\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_66_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_66_CLK sky130_fd_sc_hd__clkbuf_8
X_7525_ _3716_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4737_ _1487_ _1489_ _1492_ _1213_ _1057_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__a221o_1
XFILLER_0_44_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4668_ _1422_ _1423_ _1190_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__mux2_1
X_7456_ _3052_ net967 _3675_ VGND VGND VPWR VPWR _3680_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold930 regfile.registers\[31\]\[24\] VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__dlygate4sd3_1
X_6407_ _3092_ VGND VGND VPWR VPWR _3093_ sky130_fd_sc_hd__clkbuf_8
X_4599_ _1353_ _1354_ _1199_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold963 regfile.registers\[23\]\[26\] VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__dlygate4sd3_1
X_9126_ clknet_leaf_70_CLK _0286_ VGND VGND VPWR VPWR regfile.registers\[28\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_7387_ _3052_ net997 _3638_ VGND VGND VPWR VPWR _3643_ sky130_fd_sc_hd__mux2_1
Xhold952 regfile.registers\[29\]\[2\] VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__dlygate4sd3_1
Xhold941 regfile.registers\[3\]\[11\] VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__dlygate4sd3_1
Xhold996 regfile.registers\[25\]\[25\] VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__dlygate4sd3_1
X_6338_ _3045_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__clkbuf_1
Xhold985 regfile.registers\[15\]\[2\] VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__dlygate4sd3_1
Xhold974 regfile.registers\[27\]\[17\] VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__dlygate4sd3_1
X_6269_ _2992_ _2993_ VGND VGND VPWR VPWR _2994_ sky130_fd_sc_hd__xnor2_1
X_9057_ clknet_leaf_85_CLK _0217_ VGND VGND VPWR VPWR regfile.registers\[26\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_8008_ _3130_ net716 _3963_ VGND VGND VPWR VPWR _3972_ sky130_fd_sc_hd__mux2_1
XFILLER_0_98_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_88_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_57_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_57_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_10_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_97_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5640_ _1668_ _1780_ VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__nor2_1
Xclkbuf_leaf_48_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_48_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_98_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5571_ _1803_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4522_ _1256_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__nand2_1
X_8290_ _3139_ net668 _4119_ VGND VGND VPWR VPWR _4122_ sky130_fd_sc_hd__mux2_1
X_7310_ _3590_ VGND VGND VPWR VPWR _3602_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_26_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold215 regfile.registers\[7\]\[27\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
X_4453_ regfile.registers\[4\]\[29\] regfile.registers\[5\]\[29\] regfile.registers\[6\]\[29\]
+ regfile.registers\[7\]\[29\] _1207_ _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__mux4_1
Xhold226 regfile.registers\[2\]\[8\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
X_7241_ net379 _3512_ _3564_ VGND VGND VPWR VPWR _3565_ sky130_fd_sc_hd__mux2_1
Xhold204 regfile.registers\[8\]\[15\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 regfile.registers\[4\]\[27\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
Xhold248 regfile.registers\[12\]\[8\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold237 regfile.registers\[18\]\[11\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
X_4384_ regfile.registers\[4\]\[1\] regfile.registers\[5\]\[1\] regfile.registers\[6\]\[1\]
+ regfile.registers\[7\]\[1\] net99 _1090_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__mux4_1
X_7172_ net22 VGND VGND VPWR VPWR _3523_ sky130_fd_sc_hd__buf_2
X_6123_ _2854_ _2855_ VGND VGND VPWR VPWR _2856_ sky130_fd_sc_hd__xnor2_1
X_6054_ _2752_ _2790_ _1147_ VGND VGND VPWR VPWR _2791_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5005_ _1759_ _1760_ _1726_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6956_ _3375_ VGND VGND VPWR VPWR _3398_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_120_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5907_ _2458_ _2487_ _2651_ _2530_ VGND VGND VPWR VPWR _2652_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_66_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6887_ _3361_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_118_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_39_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_39_CLK sky130_fd_sc_hd__clkbuf_8
X_8626_ clknet_leaf_48_CLK _0810_ VGND VGND VPWR VPWR regfile.registers\[17\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_5838_ _2105_ _2584_ _2487_ _2585_ VGND VGND VPWR VPWR _2586_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_76_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5769_ _2518_ _2519_ VGND VGND VPWR VPWR _2520_ sky130_fd_sc_hd__xnor2_1
X_8557_ _4262_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7508_ _3707_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_118_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8488_ _4226_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7439_ _3035_ net984 _3664_ VGND VGND VPWR VPWR _3671_ sky130_fd_sc_hd__mux2_1
Xhold771 regfile.registers\[31\]\[22\] VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlygate4sd3_1
Xhold760 regfile.registers\[29\]\[19\] VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlygate4sd3_1
Xhold782 regfile.registers\[26\]\[11\] VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__dlygate4sd3_1
X_9109_ clknet_leaf_29_CLK _0269_ VGND VGND VPWR VPWR regfile.registers\[27\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold793 regfile.registers\[25\]\[14\] VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6810_ _3320_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7790_ net159 _3515_ _3855_ VGND VGND VPWR VPWR _3857_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6741_ net284 _3124_ _3278_ VGND VGND VPWR VPWR _3284_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_102_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9460_ clknet_leaf_16_CLK _0620_ VGND VGND VPWR VPWR regfile.registers\[13\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_6672_ _3247_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5623_ _2377_ VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__inv_2
X_9391_ clknet_leaf_1_CLK _0551_ VGND VGND VPWR VPWR regfile.registers\[24\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_8411_ net680 _3523_ _4180_ VGND VGND VPWR VPWR _4186_ sky130_fd_sc_hd__mux2_1
XFILLER_0_116_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8342_ _4149_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5554_ _2308_ _2309_ _1684_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__mux2_1
X_4505_ regfile.registers\[28\]\[21\] regfile.registers\[29\]\[21\] regfile.registers\[30\]\[21\]
+ regfile.registers\[31\]\[21\] _1220_ _1222_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__mux4_2
X_5485_ regfile.registers\[4\]\[9\] regfile.registers\[5\]\[9\] regfile.registers\[6\]\[9\]
+ regfile.registers\[7\]\[9\] _1734_ _1735_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__mux4_1
X_8273_ _3122_ net468 _4108_ VGND VGND VPWR VPWR _4113_ sky130_fd_sc_hd__mux2_1
X_4436_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__buf_12
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7224_ net469 _3496_ _3553_ VGND VGND VPWR VPWR _3556_ sky130_fd_sc_hd__mux2_1
X_7155_ _3511_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_4367_ _1121_ _1122_ _1047_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__mux2_1
X_6106_ _2838_ _2839_ VGND VGND VPWR VPWR _2840_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7086_ _3467_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
X_4298_ regfile.registers\[8\]\[4\] regfile.registers\[9\]\[4\] regfile.registers\[10\]\[4\]
+ regfile.registers\[11\]\[4\] _1052_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__mux4_1
X_6037_ _2769_ _2774_ VGND VGND VPWR VPWR _2775_ sky130_fd_sc_hd__xnor2_1
Xrebuffer30 _2689_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd1_1
X_7988_ _3961_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6939_ _3389_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8609_ clknet_leaf_83_CLK _0793_ VGND VGND VPWR VPWR regfile.registers\[17\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_9589_ clknet_leaf_31_CLK _0749_ VGND VGND VPWR VPWR regfile.registers\[10\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_107_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold590 regfile.registers\[8\]\[11\] VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5270_ _1889_ _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8960_ clknet_leaf_75_CLK _0120_ VGND VGND VPWR VPWR regfile.registers\[7\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_7911_ _3101_ net568 _3916_ VGND VGND VPWR VPWR _3921_ sky130_fd_sc_hd__mux2_1
X_8891_ clknet_leaf_42_CLK _0051_ VGND VGND VPWR VPWR regfile.registers\[4\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7842_ _3884_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4985_ regfile.registers\[28\]\[22\] regfile.registers\[29\]\[22\] regfile.registers\[30\]\[22\]
+ regfile.registers\[31\]\[22\] _1734_ _1735_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__mux4_1
XFILLER_0_77_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7773_ net410 _3498_ _3844_ VGND VGND VPWR VPWR _3848_ sky130_fd_sc_hd__mux2_1
X_6724_ net663 _3107_ _3267_ VGND VGND VPWR VPWR _3275_ sky130_fd_sc_hd__mux2_1
X_9512_ clknet_leaf_100_CLK _0672_ VGND VGND VPWR VPWR regfile.registers\[12\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_9443_ clknet_leaf_83_CLK _0603_ VGND VGND VPWR VPWR regfile.registers\[13\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6655_ _3238_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5606_ _1667_ _2272_ VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__nand2_1
X_9374_ clknet_leaf_73_CLK _0534_ VGND VGND VPWR VPWR regfile.registers\[24\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6586_ _3201_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_115_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5537_ regfile.registers\[28\]\[4\] regfile.registers\[29\]\[4\] regfile.registers\[30\]\[4\]
+ regfile.registers\[31\]\[4\] _2050_ _2052_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__mux4_1
X_8325_ _4140_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_115_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8256_ _3105_ net384 _4097_ VGND VGND VPWR VPWR _4104_ sky130_fd_sc_hd__mux2_1
X_7207_ _3546_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
X_5468_ _1697_ _2223_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_74_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4419_ _1174_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__buf_4
X_8187_ _4067_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__clkbuf_1
X_5399_ _1711_ _2154_ _1655_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_6_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7138_ net42 VGND VGND VPWR VPWR _3500_ sky130_fd_sc_hd__buf_2
X_7069_ _3458_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_126_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput19 WD3[12] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
XFILLER_0_25_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4770_ _1524_ _1525_ _1035_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6440_ _3115_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6371_ _3067_ net921 _3065_ VGND VGND VPWR VPWR _3068_ sky130_fd_sc_hd__mux2_1
X_8110_ net141 _3494_ _4025_ VGND VGND VPWR VPWR _4027_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5322_ _2076_ _2077_ _1684_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__mux2_1
X_9090_ clknet_leaf_86_CLK _0250_ VGND VGND VPWR VPWR regfile.registers\[27\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5253_ _2007_ _2008_ _1713_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__mux2_1
X_8041_ _3990_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__clkbuf_1
X_5184_ _1938_ _1939_ _1713_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_110_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8943_ clknet_leaf_1_CLK _0103_ VGND VGND VPWR VPWR regfile.registers\[3\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_8874_ clknet_leaf_98_CLK _0034_ VGND VGND VPWR VPWR regfile.registers\[4\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_7825_ net424 _3482_ _3866_ VGND VGND VPWR VPWR _3875_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7756_ _3838_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__clkbuf_1
X_4968_ regfile.registers\[4\]\[23\] regfile.registers\[5\]\[23\] regfile.registers\[6\]\[23\]
+ regfile.registers\[7\]\[23\] _1720_ _1723_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__mux4_1
XFILLER_0_19_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7687_ net354 _3480_ _3794_ VGND VGND VPWR VPWR _3802_ sky130_fd_sc_hd__mux2_1
X_6707_ _3265_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4899_ net4 VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_50_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9426_ clknet_leaf_47_CLK _0586_ VGND VGND VPWR VPWR regfile.registers\[1\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_6638_ _3228_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9357_ clknet_leaf_94_CLK _0517_ VGND VGND VPWR VPWR regfile.registers\[20\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_8308_ _3017_ net515 _4096_ VGND VGND VPWR VPWR _4131_ sky130_fd_sc_hd__mux2_1
X_6569_ net10 net9 net48 VGND VGND VPWR VPWR _3191_ sky130_fd_sc_hd__or3b_1
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9288_ clknet_leaf_102_CLK _0448_ VGND VGND VPWR VPWR regfile.registers\[25\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_8239_ _4094_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_626 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5940_ _1480_ VGND VGND VPWR VPWR _2683_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7610_ _3761_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5871_ _2600_ _2601_ VGND VGND VPWR VPWR _2618_ sky130_fd_sc_hd__and2_1
X_8590_ clknet_leaf_4_CLK _0774_ VGND VGND VPWR VPWR regfile.registers\[23\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_4822_ _1574_ _1575_ _1576_ _1577_ _1287_ _1078_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_117_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7541_ _3069_ net1109 _3722_ VGND VGND VPWR VPWR _3725_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4753_ _1507_ _1508_ _1211_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_16_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7472_ _3688_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9211_ clknet_leaf_26_CLK _0371_ VGND VGND VPWR VPWR regfile.registers\[30\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_4684_ regfile.registers\[12\]\[22\] regfile.registers\[13\]\[22\] regfile.registers\[14\]\[22\]
+ regfile.registers\[15\]\[22\] _1192_ _1195_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__mux4_1
X_6423_ net891 _3103_ _3093_ VGND VGND VPWR VPWR _3104_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9142_ clknet_leaf_51_CLK _0302_ VGND VGND VPWR VPWR regfile.registers\[28\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_6354_ net23 VGND VGND VPWR VPWR _3056_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_58_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6285_ _3008_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__clkbuf_1
X_9073_ clknet_leaf_5_CLK _0233_ VGND VGND VPWR VPWR regfile.registers\[26\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_5305_ _1699_ _2060_ _1670_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__o21ai_1
X_8024_ _3980_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__clkbuf_1
X_5236_ _1889_ _1991_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_126_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5167_ _1777_ _1912_ _1916_ _1922_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_75_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5098_ regfile.registers\[4\]\[17\] regfile.registers\[5\]\[17\] regfile.registers\[6\]\[17\]
+ regfile.registers\[7\]\[17\] _1822_ _1823_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8926_ clknet_leaf_71_CLK _0086_ VGND VGND VPWR VPWR regfile.registers\[3\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_123_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8857_ clknet_leaf_48_CLK _0017_ VGND VGND VPWR VPWR regfile.registers\[5\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8788_ clknet_leaf_23_CLK _0972_ VGND VGND VPWR VPWR regfile.registers\[14\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_7808_ _3843_ VGND VGND VPWR VPWR _3866_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_19_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7739_ _3829_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9409_ clknet_leaf_65_CLK _0569_ VGND VGND VPWR VPWR regfile.registers\[1\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold408 regfile.registers\[20\]\[4\] VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold419 regfile.registers\[29\]\[6\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6070_ _1798_ _2805_ VGND VGND VPWR VPWR _2806_ sky130_fd_sc_hd__nor2_1
X_5021_ _1729_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__clkbuf_8
X_6972_ _3406_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_8711_ clknet_leaf_62_CLK _0895_ VGND VGND VPWR VPWR regfile.registers\[15\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_5923_ _2645_ _2642_ _2664_ _2635_ _2666_ VGND VGND VPWR VPWR _2667_ sky130_fd_sc_hd__a221oi_2
XTAP_TAPCELL_ROW_105_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5854_ _2600_ _2601_ VGND VGND VPWR VPWR _2602_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8642_ clknet_leaf_85_CLK _0826_ VGND VGND VPWR VPWR regfile.registers\[22\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8573_ clknet_leaf_14_CLK _0757_ VGND VGND VPWR VPWR regfile.registers\[10\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_4805_ regfile.registers\[16\]\[11\] regfile.registers\[17\]\[11\] regfile.registers\[18\]\[11\]
+ regfile.registers\[19\]\[11\] net97 _1073_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__mux4_1
XFILLER_0_118_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5785_ _1059_ _1083_ VGND VGND VPWR VPWR _2535_ sky130_fd_sc_hd__and2_1
X_7524_ _3052_ net933 _3711_ VGND VGND VPWR VPWR _3716_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4736_ _1490_ _1491_ _1287_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__mux2_1
X_4667_ regfile.registers\[12\]\[23\] regfile.registers\[13\]\[23\] regfile.registers\[14\]\[23\]
+ regfile.registers\[15\]\[23\] _1267_ _1268_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__mux4_1
X_7455_ _3679_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
Xhold920 regfile.registers\[30\]\[21\] VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6406_ _3090_ _3091_ VGND VGND VPWR VPWR _3092_ sky130_fd_sc_hd__nor2_4
Xhold931 regfile.registers\[26\]\[1\] VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__dlygate4sd3_1
X_7386_ _3642_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
X_4598_ regfile.registers\[16\]\[25\] regfile.registers\[17\]\[25\] regfile.registers\[18\]\[25\]
+ regfile.registers\[19\]\[25\] _1351_ _1352_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__mux4_1
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold953 regfile.registers\[27\]\[19\] VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__dlygate4sd3_1
Xhold964 regfile.registers\[5\]\[18\] VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__dlygate4sd3_1
X_9125_ clknet_leaf_68_CLK _0285_ VGND VGND VPWR VPWR regfile.registers\[28\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_6337_ _3043_ net1110 _3044_ VGND VGND VPWR VPWR _3045_ sky130_fd_sc_hd__mux2_1
Xhold942 regfile.registers\[23\]\[14\] VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__dlygate4sd3_1
Xhold986 regfile.registers\[28\]\[23\] VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold975 regfile.registers\[4\]\[18\] VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold997 regfile.registers\[13\]\[3\] VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__dlygate4sd3_1
X_6268_ _1334_ _1904_ VGND VGND VPWR VPWR _2993_ sky130_fd_sc_hd__xor2_1
X_9056_ clknet_leaf_79_CLK _0216_ VGND VGND VPWR VPWR regfile.registers\[26\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_6199_ _2475_ _2591_ _2652_ _2737_ _2927_ VGND VGND VPWR VPWR _2928_ sky130_fd_sc_hd__a221o_1
X_5219_ regfile.registers\[0\]\[27\] regfile.registers\[1\]\[27\] regfile.registers\[2\]\[27\]
+ regfile.registers\[3\]\[27\] _1895_ _1897_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__mux4_1
X_8007_ _3971_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8909_ clknet_leaf_11_CLK _0069_ VGND VGND VPWR VPWR regfile.registers\[19\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_124_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5570_ _2307_ _2325_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4521_ _1239_ _1266_ _1272_ _1276_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold205 regfile.registers\[19\]\[26\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
X_4452_ _1174_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__clkbuf_4
X_7240_ _3552_ VGND VGND VPWR VPWR _3564_ sky130_fd_sc_hd__buf_4
Xhold216 regfile.registers\[6\]\[18\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold249 regfile.registers\[11\]\[20\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
Xhold227 regfile.registers\[3\]\[9\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold238 regfile.registers\[18\]\[5\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4383_ _1038_ _1138_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__nand2_1
X_7171_ _3522_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_6122_ _2840_ _2844_ _2838_ VGND VGND VPWR VPWR _2855_ sky130_fd_sc_hd__o21ai_1
X_6053_ _1800_ _1821_ _2399_ VGND VGND VPWR VPWR _2790_ sky130_fd_sc_hd__o21a_1
X_5004_ regfile.registers\[16\]\[21\] regfile.registers\[17\]\[21\] regfile.registers\[18\]\[21\]
+ regfile.registers\[19\]\[21\] _1676_ _1681_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_107_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6955_ _3397_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_120_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5906_ _2648_ _2650_ _2501_ VGND VGND VPWR VPWR _2651_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6886_ net816 _3132_ _3351_ VGND VGND VPWR VPWR _3361_ sky130_fd_sc_hd__mux2_1
X_8625_ clknet_leaf_5_CLK _0809_ VGND VGND VPWR VPWR regfile.registers\[17\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5837_ _1758_ _2331_ _1148_ VGND VGND VPWR VPWR _2585_ sky130_fd_sc_hd__or3b_1
XFILLER_0_64_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8556_ net327 net28 _4255_ VGND VGND VPWR VPWR _4262_ sky130_fd_sc_hd__mux2_1
X_5768_ _2511_ _2512_ _2509_ VGND VGND VPWR VPWR _2519_ sky130_fd_sc_hd__a21oi_1
X_8487_ net280 net26 _4216_ VGND VGND VPWR VPWR _4226_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7507_ _3035_ net662 _3700_ VGND VGND VPWR VPWR _3707_ sky130_fd_sc_hd__mux2_1
X_4719_ _1213_ _1474_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_118_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5699_ _2449_ _2451_ VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7438_ _3670_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold761 regfile.registers\[22\]\[20\] VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlygate4sd3_1
Xhold772 regfile.registers\[23\]\[28\] VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlygate4sd3_1
Xhold750 regfile.registers\[0\]\[20\] VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dlygate4sd3_1
X_7369_ _3633_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_9108_ clknet_leaf_26_CLK _0268_ VGND VGND VPWR VPWR regfile.registers\[27\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold783 regfile.registers\[28\]\[14\] VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__dlygate4sd3_1
Xhold794 regfile.registers\[0\]\[10\] VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__dlygate4sd3_1
X_9039_ clknet_leaf_2_CLK _0199_ VGND VGND VPWR VPWR regfile.registers\[31\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6740_ _3283_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_102_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6671_ _3052_ net1075 _3242_ VGND VGND VPWR VPWR _3247_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5622_ _1168_ _1905_ VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__and2_1
X_9390_ clknet_leaf_5_CLK _0550_ VGND VGND VPWR VPWR regfile.registers\[24\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_8410_ _4185_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5553_ regfile.registers\[16\]\[5\] regfile.registers\[17\]\[5\] regfile.registers\[18\]\[5\]
+ regfile.registers\[19\]\[5\] _2050_ _2052_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__mux4_1
X_8341_ net801 _3521_ _4144_ VGND VGND VPWR VPWR _4149_ sky130_fd_sc_hd__mux2_1
X_4504_ _1257_ _1258_ _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5484_ _2238_ _2239_ _1685_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__mux2_1
X_8272_ _4112_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_111_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7223_ _3555_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
X_4435_ _1072_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__buf_12
X_7154_ net307 _3510_ _3492_ VGND VGND VPWR VPWR _3511_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4366_ regfile.registers\[12\]\[2\] regfile.registers\[13\]\[2\] regfile.registers\[14\]\[2\]
+ regfile.registers\[15\]\[2\] net91 _1066_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__mux4_1
X_6105_ _1754_ _2837_ VGND VGND VPWR VPWR _2839_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7085_ net337 _3126_ _3460_ VGND VGND VPWR VPWR _3467_ sky130_fd_sc_hd__mux2_1
X_4297_ _1043_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__buf_4
X_6036_ _2749_ _2771_ _2773_ VGND VGND VPWR VPWR _2774_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_68_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer31 _2684_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7987_ _3109_ net952 _3952_ VGND VGND VPWR VPWR _3961_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6938_ net127 _3116_ _3387_ VGND VGND VPWR VPWR _3389_ sky130_fd_sc_hd__mux2_1
X_6869_ _3352_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9588_ clknet_leaf_17_CLK _0748_ VGND VGND VPWR VPWR regfile.registers\[10\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8608_ clknet_leaf_77_CLK _0792_ VGND VGND VPWR VPWR regfile.registers\[17\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_8539_ net640 net19 _4244_ VGND VGND VPWR VPWR _4253_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_79_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold580 regfile.registers\[1\]\[18\] VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold591 regfile.registers\[30\]\[27\] VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8890_ clknet_leaf_39_CLK _0050_ VGND VGND VPWR VPWR regfile.registers\[4\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_7910_ _3920_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__clkbuf_1
X_7841_ net456 _3498_ _3880_ VGND VGND VPWR VPWR _3884_ sky130_fd_sc_hd__mux2_1
X_4984_ _1736_ _1737_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7772_ _3847_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_63_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9511_ clknet_leaf_63_CLK _0671_ VGND VGND VPWR VPWR regfile.registers\[12\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_6723_ _3274_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9442_ clknet_leaf_83_CLK _0602_ VGND VGND VPWR VPWR regfile.registers\[13\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_6654_ _3035_ net636 _3231_ VGND VGND VPWR VPWR _3238_ sky130_fd_sc_hd__mux2_1
X_5605_ _1668_ _2324_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9373_ clknet_leaf_12_CLK _0533_ VGND VGND VPWR VPWR regfile.registers\[20\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6585_ net617 _3105_ _3194_ VGND VGND VPWR VPWR _3201_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_115_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5536_ _2290_ _2291_ _2044_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__mux2_1
X_8324_ net922 _3504_ _4133_ VGND VGND VPWR VPWR _4140_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_115_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5467_ _2221_ _2222_ _1712_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__mux2_1
X_8255_ _4103_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__clkbuf_1
X_7206_ net436 _3478_ _3534_ VGND VGND VPWR VPWR _3546_ sky130_fd_sc_hd__mux2_1
X_4418_ _1073_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__buf_4
XFILLER_0_111_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8186_ net287 _3502_ _4061_ VGND VGND VPWR VPWR _4067_ sky130_fd_sc_hd__mux2_1
X_5398_ regfile.registers\[0\]\[13\] regfile.registers\[1\]\[13\] regfile.registers\[2\]\[13\]
+ regfile.registers\[3\]\[13\] _1702_ _1678_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_6_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4349_ _1043_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__buf_4
X_7137_ _3499_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
X_7068_ net168 _3109_ _3449_ VGND VGND VPWR VPWR _3458_ sky130_fd_sc_hd__mux2_1
X_6019_ _1127_ _2524_ _2737_ _2503_ VGND VGND VPWR VPWR _2758_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_126_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6370_ net29 VGND VGND VPWR VPWR _3067_ sky130_fd_sc_hd__buf_2
XFILLER_0_3_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5321_ regfile.registers\[0\]\[2\] regfile.registers\[1\]\[2\] regfile.registers\[2\]\[2\]
+ regfile.registers\[3\]\[2\] _1701_ _1677_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8040_ net865 _3490_ _3989_ VGND VGND VPWR VPWR _3990_ sky130_fd_sc_hd__mux2_1
XFILLER_0_121_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5252_ regfile.registers\[12\]\[25\] regfile.registers\[13\]\[25\] regfile.registers\[14\]\[25\]
+ regfile.registers\[15\]\[25\] _1895_ _1897_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__mux4_1
XFILLER_0_54_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5183_ regfile.registers\[12\]\[29\] regfile.registers\[13\]\[29\] regfile.registers\[14\]\[29\]
+ regfile.registers\[15\]\[29\] _1767_ _1768_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__mux4_1
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8942_ clknet_leaf_5_CLK _0102_ VGND VGND VPWR VPWR regfile.registers\[3\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_8873_ clknet_leaf_100_CLK _0033_ VGND VGND VPWR VPWR regfile.registers\[4\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_7824_ _3874_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__clkbuf_1
X_7755_ _3079_ net671 _3830_ VGND VGND VPWR VPWR _3838_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4967_ _1722_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__buf_4
XFILLER_0_117_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7686_ _3801_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__clkbuf_1
X_6706_ _3087_ net615 _3230_ VGND VGND VPWR VPWR _3265_ sky130_fd_sc_hd__mux2_1
X_4898_ net4 _1653_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6637_ net881 _3017_ _3193_ VGND VGND VPWR VPWR _3228_ sky130_fd_sc_hd__mux2_1
X_9425_ clknet_leaf_18_CLK _0585_ VGND VGND VPWR VPWR regfile.registers\[1\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6568_ net13 net12 net11 VGND VGND VPWR VPWR _3190_ sky130_fd_sc_hd__or3_2
XFILLER_0_61_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9356_ clknet_leaf_0_CLK _0516_ VGND VGND VPWR VPWR regfile.registers\[20\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8307_ _4130_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_76_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5519_ regfile.registers\[16\]\[7\] regfile.registers\[17\]\[7\] regfile.registers\[18\]\[7\]
+ regfile.registers\[19\]\[7\] _2051_ _2053_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__mux4_1
XFILLER_0_100_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6499_ net9 _3004_ VGND VGND VPWR VPWR _3153_ sky130_fd_sc_hd__nor2_4
X_9287_ clknet_leaf_62_CLK _0447_ VGND VGND VPWR VPWR regfile.registers\[25\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_8238_ net429 _3486_ _4060_ VGND VGND VPWR VPWR _4094_ sky130_fd_sc_hd__mux2_1
X_8169_ _4057_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5870_ _2616_ _2246_ VGND VGND VPWR VPWR _2617_ sky130_fd_sc_hd__xor2_2
X_4821_ regfile.registers\[20\]\[16\] regfile.registers\[21\]\[16\] regfile.registers\[22\]\[16\]
+ regfile.registers\[23\]\[16\] _1291_ _1194_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7540_ _3724_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
X_4752_ regfile.registers\[0\]\[15\] regfile.registers\[1\]\[15\] regfile.registers\[2\]\[15\]
+ regfile.registers\[3\]\[15\] _1192_ _1195_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7471_ _3067_ net1132 _3686_ VGND VGND VPWR VPWR _3688_ sky130_fd_sc_hd__mux2_1
X_4683_ _1189_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__or2_1
XFILLER_0_114_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9210_ clknet_leaf_25_CLK _0370_ VGND VGND VPWR VPWR regfile.registers\[30\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_6422_ net43 VGND VGND VPWR VPWR _3103_ sky130_fd_sc_hd__buf_2
X_9141_ clknet_leaf_29_CLK _0301_ VGND VGND VPWR VPWR regfile.registers\[28\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_114_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6353_ _3055_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6284_ net556 _3002_ _3007_ VGND VGND VPWR VPWR _3008_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_58_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5304_ _2058_ _2059_ _1685_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__mux2_1
X_9072_ clknet_leaf_7_CLK _0232_ VGND VGND VPWR VPWR regfile.registers\[26\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_8023_ _3145_ net980 _3974_ VGND VGND VPWR VPWR _3980_ sky130_fd_sc_hd__mux2_1
X_5235_ regfile.registers\[4\]\[26\] regfile.registers\[5\]\[26\] regfile.registers\[6\]\[26\]
+ regfile.registers\[7\]\[26\] _1896_ _1898_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_71_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5166_ _1766_ _1921_ _1672_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__o21ai_1
X_5097_ _1700_ _1852_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8925_ clknet_leaf_44_CLK _0085_ VGND VGND VPWR VPWR regfile.registers\[19\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_123_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8856_ clknet_leaf_14_CLK _0016_ VGND VGND VPWR VPWR regfile.registers\[5\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8787_ clknet_leaf_33_CLK _0971_ VGND VGND VPWR VPWR regfile.registers\[14\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5999_ _2585_ _2738_ _2333_ VGND VGND VPWR VPWR _2739_ sky130_fd_sc_hd__o21ai_1
X_7807_ _3865_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7738_ _3062_ net546 _3819_ VGND VGND VPWR VPWR _3829_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7669_ _3792_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
X_9408_ clknet_leaf_77_CLK _0568_ VGND VGND VPWR VPWR regfile.registers\[1\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9339_ clknet_leaf_27_CLK _0499_ VGND VGND VPWR VPWR regfile.registers\[21\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold409 regfile.registers\[13\]\[13\] VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5020_ _1774_ _1775_ _1726_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6971_ net228 _3009_ _3398_ VGND VGND VPWR VPWR _3406_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8710_ clknet_leaf_56_CLK _0894_ VGND VGND VPWR VPWR regfile.registers\[15\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_5922_ _2193_ _2640_ _2641_ VGND VGND VPWR VPWR _2666_ sky130_fd_sc_hd__and3_1
X_5853_ _2539_ _2559_ _2560_ VGND VGND VPWR VPWR _2601_ sky130_fd_sc_hd__o21ai_2
X_8641_ clknet_leaf_84_CLK _0825_ VGND VGND VPWR VPWR regfile.registers\[22\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_5784_ _2534_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_1
X_8572_ clknet_leaf_14_CLK _0756_ VGND VGND VPWR VPWR regfile.registers\[10\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4804_ regfile.registers\[28\]\[11\] regfile.registers\[29\]\[11\] regfile.registers\[30\]\[11\]
+ regfile.registers\[31\]\[11\] _1042_ _1044_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7523_ _3715_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
X_4735_ regfile.registers\[12\]\[14\] regfile.registers\[13\]\[14\] regfile.registers\[14\]\[14\]
+ regfile.registers\[15\]\[14\] _1172_ _1279_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4666_ regfile.registers\[8\]\[23\] regfile.registers\[9\]\[23\] regfile.registers\[10\]\[23\]
+ regfile.registers\[11\]\[23\] _1267_ _1268_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__mux4_1
X_7454_ _3050_ net961 _3675_ VGND VGND VPWR VPWR _3679_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4597_ regfile.registers\[20\]\[25\] regfile.registers\[21\]\[25\] regfile.registers\[22\]\[25\]
+ regfile.registers\[23\]\[25\] _1351_ _1352_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6405_ net10 net9 net48 VGND VGND VPWR VPWR _3091_ sky130_fd_sc_hd__nand3b_4
X_7385_ _3050_ net849 _3638_ VGND VGND VPWR VPWR _3642_ sky130_fd_sc_hd__mux2_1
Xhold910 regfile.registers\[22\]\[1\] VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__dlygate4sd3_1
Xhold921 regfile.registers\[31\]\[6\] VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold943 regfile.registers\[26\]\[22\] VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__dlygate4sd3_1
Xhold954 regfile.registers\[31\]\[26\] VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__dlygate4sd3_1
X_6336_ _3022_ VGND VGND VPWR VPWR _3044_ sky130_fd_sc_hd__clkbuf_8
Xhold932 regfile.registers\[15\]\[13\] VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__dlygate4sd3_1
X_9124_ clknet_leaf_91_CLK _0284_ VGND VGND VPWR VPWR regfile.registers\[28\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold987 regfile.registers\[23\]\[11\] VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__dlygate4sd3_1
Xhold976 regfile.registers\[30\]\[11\] VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__dlygate4sd3_1
X_9055_ clknet_leaf_80_CLK _0215_ VGND VGND VPWR VPWR regfile.registers\[26\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold965 regfile.registers\[23\]\[2\] VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__dlygate4sd3_1
Xhold998 regfile.registers\[22\]\[2\] VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__dlygate4sd3_1
X_6267_ net103 _2981_ _2741_ VGND VGND VPWR VPWR _2992_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6198_ _2530_ _2792_ _2922_ _2926_ VGND VGND VPWR VPWR _2927_ sky130_fd_sc_hd__o211a_1
X_5218_ regfile.registers\[4\]\[27\] regfile.registers\[5\]\[27\] regfile.registers\[6\]\[27\]
+ regfile.registers\[7\]\[27\] _1918_ _1919_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__mux4_1
X_8006_ _3128_ net782 _3963_ VGND VGND VPWR VPWR _3971_ sky130_fd_sc_hd__mux2_1
X_5149_ _1842_ _1904_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_84_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8908_ clknet_leaf_110_CLK _0068_ VGND VGND VPWR VPWR regfile.registers\[19\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8839_ clknet_leaf_67_CLK _1023_ VGND VGND VPWR VPWR regfile.registers\[5\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4520_ _1254_ _1275_ _1171_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold206 regfile.registers\[16\]\[21\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_103_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4451_ _1191_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__buf_12
Xhold217 regfile.registers\[20\]\[11\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
Xhold228 regfile.registers\[7\]\[25\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold239 regfile.registers\[28\]\[26\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
X_7170_ net900 _3521_ _3513_ VGND VGND VPWR VPWR _3522_ sky130_fd_sc_hd__mux2_1
X_6121_ _1731_ _2853_ VGND VGND VPWR VPWR _2854_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_55_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4382_ _1136_ _1137_ _1047_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6052_ _2421_ _2788_ VGND VGND VPWR VPWR _2789_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5003_ regfile.registers\[20\]\[21\] regfile.registers\[21\]\[21\] regfile.registers\[22\]\[21\]
+ regfile.registers\[23\]\[21\] _1676_ _1681_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_107_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6954_ net403 _3132_ _3387_ VGND VGND VPWR VPWR _3397_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5905_ _2609_ _2649_ _1803_ VGND VGND VPWR VPWR _2650_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6885_ _3360_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__clkbuf_1
X_8624_ clknet_leaf_11_CLK _0808_ VGND VGND VPWR VPWR regfile.registers\[17\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_5836_ _2579_ _2583_ _2252_ VGND VGND VPWR VPWR _2584_ sky130_fd_sc_hd__mux2_1
XFILLER_0_118_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8555_ _4261_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__clkbuf_1
X_5767_ _2516_ _2517_ VGND VGND VPWR VPWR _2518_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5698_ _2449_ _2451_ VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__nand2_1
X_8486_ _4225_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__clkbuf_1
X_7506_ _3706_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
X_4718_ _1472_ _1473_ _1287_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7437_ _3033_ net745 _3664_ VGND VGND VPWR VPWR _3670_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4649_ _1403_ _1404_ _1107_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold751 regfile.registers\[24\]\[22\] VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dlygate4sd3_1
Xhold762 regfile.registers\[4\]\[26\] VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlygate4sd3_1
Xhold740 regfile.registers\[17\]\[31\] VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dlygate4sd3_1
X_7368_ _3033_ net652 _3627_ VGND VGND VPWR VPWR _3633_ sky130_fd_sc_hd__mux2_1
Xhold773 regfile.registers\[20\]\[14\] VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
X_9107_ clknet_leaf_27_CLK _0267_ VGND VGND VPWR VPWR regfile.registers\[27\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold795 regfile.registers\[29\]\[7\] VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__dlygate4sd3_1
Xhold784 regfile.registers\[29\]\[12\] VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__dlygate4sd3_1
X_7299_ _3596_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
X_6319_ _3032_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__clkbuf_1
X_9038_ clknet_leaf_3_CLK _0198_ VGND VGND VPWR VPWR regfile.registers\[31\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_107_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_107_CLK
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_23_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6670_ _3246_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__clkbuf_1
X_5621_ _2335_ _2337_ _2340_ _2375_ _2333_ VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__o311a_1
XFILLER_0_54_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5552_ regfile.registers\[20\]\[5\] regfile.registers\[21\]\[5\] regfile.registers\[22\]\[5\]
+ regfile.registers\[23\]\[5\] _2050_ _2052_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__mux4_1
X_8340_ _4148_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8271_ _3120_ net489 _4108_ VGND VGND VPWR VPWR _4112_ sky130_fd_sc_hd__mux2_1
X_4503_ _1036_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_124_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5483_ regfile.registers\[8\]\[9\] regfile.registers\[9\]\[9\] regfile.registers\[10\]\[9\]
+ regfile.registers\[11\]\[9\] _1782_ _1692_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_20_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7222_ net575 _3494_ _3553_ VGND VGND VPWR VPWR _3555_ sky130_fd_sc_hd__mux2_1
X_4434_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__buf_6
X_7153_ net47 VGND VGND VPWR VPWR _3510_ sky130_fd_sc_hd__buf_2
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4365_ regfile.registers\[8\]\[2\] regfile.registers\[9\]\[2\] regfile.registers\[10\]\[2\]
+ regfile.registers\[11\]\[2\] net91 _1066_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_113_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6104_ _1754_ _2837_ VGND VGND VPWR VPWR _2838_ sky130_fd_sc_hd__nand2_1
X_7084_ _3466_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
X_6035_ _1858_ _2762_ _2772_ VGND VGND VPWR VPWR _2773_ sky130_fd_sc_hd__a21o_1
X_4296_ _1041_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__buf_12
Xrebuffer21 _1573_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer10 _2506_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_68_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer32 _1217_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_96_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7986_ _3960_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6937_ _3388_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_6868_ net395 _3113_ _3351_ VGND VGND VPWR VPWR _3352_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_40_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9587_ clknet_leaf_33_CLK _0747_ VGND VGND VPWR VPWR regfile.registers\[10\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5819_ _2458_ _2567_ _1126_ VGND VGND VPWR VPWR _2568_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8607_ clknet_leaf_81_CLK _0791_ VGND VGND VPWR VPWR regfile.registers\[17\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6799_ _3043_ net790 _3314_ VGND VGND VPWR VPWR _3315_ sky130_fd_sc_hd__mux2_1
X_8538_ _4252_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_79_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8469_ net1016 net17 _4216_ VGND VGND VPWR VPWR _4217_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold581 regfile.registers\[20\]\[26\] VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dlygate4sd3_1
Xhold570 regfile.registers\[26\]\[4\] VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dlygate4sd3_1
Xhold592 regfile.registers\[11\]\[11\] VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_48_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7840_ _3883_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7771_ net837 _3496_ _3844_ VGND VGND VPWR VPWR _3847_ sky130_fd_sc_hd__mux2_1
X_4983_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_53_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9510_ clknet_leaf_67_CLK _0670_ VGND VGND VPWR VPWR regfile.registers\[12\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_6722_ net810 _3105_ _3267_ VGND VGND VPWR VPWR _3274_ sky130_fd_sc_hd__mux2_1
X_6653_ _3237_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__clkbuf_1
X_9441_ clknet_leaf_81_CLK _0601_ VGND VGND VPWR VPWR regfile.registers\[13\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_5604_ _2357_ _2358_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__and2_1
X_9372_ clknet_leaf_42_CLK _0532_ VGND VGND VPWR VPWR regfile.registers\[20\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6584_ _3200_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__clkbuf_1
X_5535_ regfile.registers\[16\]\[4\] regfile.registers\[17\]\[4\] regfile.registers\[18\]\[4\]
+ regfile.registers\[19\]\[4\] _2050_ _2052_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__mux4_1
XFILLER_0_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8323_ _4139_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_115_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5466_ regfile.registers\[12\]\[8\] regfile.registers\[13\]\[8\] regfile.registers\[14\]\[8\]
+ regfile.registers\[15\]\[8\] _1719_ _1722_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__mux4_1
X_8254_ _3103_ net836 _4097_ VGND VGND VPWR VPWR _4103_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7205_ _3545_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
X_4417_ _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_74_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8185_ _4066_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__clkbuf_1
X_5397_ _1684_ _2152_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_6_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4348_ _1041_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__buf_12
X_7136_ net600 _3498_ _3492_ VGND VGND VPWR VPWR _3499_ sky130_fd_sc_hd__mux2_1
X_7067_ _3457_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_4279_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__buf_4
X_6018_ _2527_ _2756_ _2426_ VGND VGND VPWR VPWR _2757_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7969_ _3020_ _3588_ VGND VGND VPWR VPWR _3951_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_25_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer1 _1237_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_11_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5320_ regfile.registers\[4\]\[2\] regfile.registers\[5\]\[2\] regfile.registers\[6\]\[2\]
+ regfile.registers\[7\]\[2\] _1701_ _1677_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__mux4_1
XFILLER_0_51_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5251_ regfile.registers\[8\]\[25\] regfile.registers\[9\]\[25\] regfile.registers\[10\]\[25\]
+ regfile.registers\[11\]\[25\] _1895_ _1897_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__mux4_1
XFILLER_0_48_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5182_ regfile.registers\[8\]\[29\] regfile.registers\[9\]\[29\] regfile.registers\[10\]\[29\]
+ regfile.registers\[11\]\[29\] _1767_ _1768_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_110_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8941_ clknet_leaf_94_CLK _0101_ VGND VGND VPWR VPWR regfile.registers\[3\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8872_ clknet_leaf_88_CLK _0032_ VGND VGND VPWR VPWR regfile.registers\[4\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_7823_ net460 _3480_ _3866_ VGND VGND VPWR VPWR _3874_ sky130_fd_sc_hd__mux2_1
X_7754_ _3837_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_96_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_96_CLK sky130_fd_sc_hd__clkbuf_8
X_6705_ _3264_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4966_ _1721_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__buf_4
X_7685_ net795 _3478_ _3794_ VGND VGND VPWR VPWR _3801_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4897_ _1651_ _1652_ net3 VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_50_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6636_ _3227_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9424_ clknet_leaf_10_CLK _0584_ VGND VGND VPWR VPWR regfile.registers\[1\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6567_ _3189_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9355_ clknet_leaf_103_CLK _0515_ VGND VGND VPWR VPWR regfile.registers\[20\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8306_ _3015_ net761 _4096_ VGND VGND VPWR VPWR _4130_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5518_ regfile.registers\[28\]\[7\] regfile.registers\[29\]\[7\] regfile.registers\[30\]\[7\]
+ regfile.registers\[31\]\[7\] _2051_ _2053_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__mux4_1
X_6498_ _3152_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__clkbuf_1
X_9286_ clknet_leaf_69_CLK _0446_ VGND VGND VPWR VPWR regfile.registers\[25\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_112_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8237_ _4093_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5449_ _1699_ _2204_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__nand2_1
X_8168_ net819 _3484_ _4047_ VGND VGND VPWR VPWR _4057_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_20_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_20_CLK sky130_fd_sc_hd__clkbuf_8
X_7119_ net343 _3486_ _3448_ VGND VGND VPWR VPWR _3487_ sky130_fd_sc_hd__mux2_1
X_8099_ _4020_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_87_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_87_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_108_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_11_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_11_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_125_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4820_ regfile.registers\[16\]\[16\] regfile.registers\[17\]\[16\] regfile.registers\[18\]\[16\]
+ regfile.registers\[19\]\[16\] _1291_ _1194_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_78_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_78_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4751_ regfile.registers\[4\]\[15\] regfile.registers\[5\]\[15\] regfile.registers\[6\]\[15\]
+ regfile.registers\[7\]\[15\] _1192_ _1195_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_16_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7470_ _3687_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
X_4682_ regfile.registers\[8\]\[22\] regfile.registers\[9\]\[22\] regfile.registers\[10\]\[22\]
+ regfile.registers\[11\]\[22\] _1207_ _1208_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__mux4_1
XFILLER_0_16_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6421_ _3102_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9140_ clknet_leaf_22_CLK _0300_ VGND VGND VPWR VPWR regfile.registers\[28\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6352_ _3054_ net478 _3044_ VGND VGND VPWR VPWR _3055_ sky130_fd_sc_hd__mux2_1
X_6283_ _3006_ VGND VGND VPWR VPWR _3007_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_58_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9071_ clknet_leaf_1_CLK _0231_ VGND VGND VPWR VPWR regfile.registers\[26\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_5303_ regfile.registers\[0\]\[3\] regfile.registers\[1\]\[3\] regfile.registers\[2\]\[3\]
+ regfile.registers\[3\]\[3\] _1703_ _1706_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__mux4_1
X_8022_ _3979_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__clkbuf_1
X_5234_ _1988_ _1989_ _1901_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__mux2_1
X_5165_ _1917_ _1920_ _1901_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_71_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5096_ _1850_ _1851_ _1713_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__mux2_1
X_8924_ clknet_leaf_42_CLK _0084_ VGND VGND VPWR VPWR regfile.registers\[19\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclone6 A2[0] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_123_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8855_ clknet_leaf_50_CLK _0015_ VGND VGND VPWR VPWR regfile.registers\[5\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_7806_ net263 _3531_ _3855_ VGND VGND VPWR VPWR _3865_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5998_ _1127_ _2737_ VGND VGND VPWR VPWR _2738_ sky130_fd_sc_hd__nand2_1
X_8786_ clknet_leaf_45_CLK _0970_ VGND VGND VPWR VPWR regfile.registers\[14\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_69_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_69_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_35_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4949_ _1704_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_82_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7737_ _3828_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__clkbuf_1
X_7668_ net637 _3529_ _3783_ VGND VGND VPWR VPWR _3792_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6619_ net532 _3139_ _3216_ VGND VGND VPWR VPWR _3219_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9407_ clknet_leaf_75_CLK _0567_ VGND VGND VPWR VPWR regfile.registers\[1\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_49_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7599_ _3755_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
X_9338_ clknet_leaf_24_CLK _0498_ VGND VGND VPWR VPWR regfile.registers\[21\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_9269_ clknet_leaf_34_CLK _0429_ VGND VGND VPWR VPWR regfile.registers\[18\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_100_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_0_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_0_CLK sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_67_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6970_ _3405_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_5921_ _2617_ _2598_ _2664_ VGND VGND VPWR VPWR _2665_ sky130_fd_sc_hd__nand3_2
XFILLER_0_48_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5852_ _2511_ _2512_ _2518_ _2542_ _2599_ VGND VGND VPWR VPWR _2600_ sky130_fd_sc_hd__a311o_1
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8640_ clknet_leaf_77_CLK _0824_ VGND VGND VPWR VPWR regfile.registers\[22\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_8571_ clknet_leaf_40_CLK _0755_ VGND VGND VPWR VPWR regfile.registers\[10\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5783_ _2521_ _2529_ _2533_ VGND VGND VPWR VPWR _2534_ sky130_fd_sc_hd__or3_1
X_4803_ regfile.registers\[24\]\[11\] regfile.registers\[25\]\[11\] regfile.registers\[26\]\[11\]
+ regfile.registers\[27\]\[11\] _1072_ _1073_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7522_ _3050_ net523 _3711_ VGND VGND VPWR VPWR _3715_ sky130_fd_sc_hd__mux2_1
X_4734_ regfile.registers\[8\]\[14\] regfile.registers\[9\]\[14\] regfile.registers\[10\]\[14\]
+ regfile.registers\[11\]\[14\] _1172_ _1279_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__mux4_1
XFILLER_0_56_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4665_ _1417_ _1418_ _1419_ _1420_ _1190_ _1205_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7453_ _3678_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold900 regfile.registers\[21\]\[25\] VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dlygate4sd3_1
X_4596_ _1325_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__buf_4
X_6404_ net12 net11 net13 VGND VGND VPWR VPWR _3090_ sky130_fd_sc_hd__or3b_4
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7384_ _3641_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
Xhold911 regfile.registers\[28\]\[6\] VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__dlygate4sd3_1
Xhold922 regfile.registers\[12\]\[6\] VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__dlygate4sd3_1
Xhold944 regfile.registers\[11\]\[27\] VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__dlygate4sd3_1
Xhold933 regfile.registers\[27\]\[10\] VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__dlygate4sd3_1
X_9123_ clknet_leaf_80_CLK _0283_ VGND VGND VPWR VPWR regfile.registers\[28\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold955 regfile.registers\[12\]\[1\] VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__dlygate4sd3_1
X_6335_ net17 VGND VGND VPWR VPWR _3043_ sky130_fd_sc_hd__clkbuf_2
Xhold977 regfile.registers\[26\]\[26\] VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__dlygate4sd3_1
Xhold966 regfile.registers\[28\]\[13\] VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__dlygate4sd3_1
Xhold988 regfile.registers\[13\]\[2\] VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__dlygate4sd3_1
X_9054_ clknet_leaf_74_CLK _0214_ VGND VGND VPWR VPWR regfile.registers\[26\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold999 regfile.registers\[31\]\[21\] VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__dlygate4sd3_1
X_6266_ _2952_ _2986_ _2987_ _2984_ VGND VGND VPWR VPWR _2991_ sky130_fd_sc_hd__a31o_1
X_8005_ _3970_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__clkbuf_1
X_6197_ _2337_ _2925_ _1086_ VGND VGND VPWR VPWR _2926_ sky130_fd_sc_hd__o21a_1
X_5217_ _1773_ _1972_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5148_ _1777_ _1890_ _1894_ _1903_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_98_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5079_ regfile.registers\[0\]\[19\] regfile.registers\[1\]\[19\] regfile.registers\[2\]\[19\]
+ regfile.registers\[3\]\[19\] _1704_ _1707_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_84_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8907_ clknet_leaf_105_CLK _0067_ VGND VGND VPWR VPWR regfile.registers\[19\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8838_ clknet_leaf_69_CLK _1022_ VGND VGND VPWR VPWR regfile.registers\[5\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_8769_ clknet_leaf_82_CLK _0953_ VGND VGND VPWR VPWR regfile.registers\[14\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4450_ _1199_ _1204_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold207 regfile.registers\[1\]\[5\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
Xhold229 regfile.registers\[6\]\[29\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
X_4381_ regfile.registers\[12\]\[1\] regfile.registers\[13\]\[1\] regfile.registers\[14\]\[1\]
+ regfile.registers\[15\]\[1\] net98 _1053_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__mux4_1
Xhold218 regfile.registers\[1\]\[0\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
X_6120_ _1430_ _2852_ VGND VGND VPWR VPWR _2853_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_84_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6051_ _2784_ _2787_ VGND VGND VPWR VPWR _2788_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5002_ _1639_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_107_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6953_ _3396_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_93_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5904_ _2352_ _2350_ VGND VGND VPWR VPWR _2649_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6884_ net296 _3130_ _3351_ VGND VGND VPWR VPWR _3360_ sky130_fd_sc_hd__mux2_1
XFILLER_0_118_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5835_ _2547_ _2582_ _2363_ VGND VGND VPWR VPWR _2583_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8623_ clknet_leaf_2_CLK _0807_ VGND VGND VPWR VPWR regfile.registers\[17\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_45_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8554_ net426 net26 _4255_ VGND VGND VPWR VPWR _4261_ sky130_fd_sc_hd__mux2_1
X_5766_ _2323_ _2515_ VGND VGND VPWR VPWR _2517_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5697_ _2450_ _2414_ _2413_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__o21bai_1
X_7505_ _3033_ net1085 _3700_ VGND VGND VPWR VPWR _3706_ sky130_fd_sc_hd__mux2_1
X_4717_ regfile.registers\[12\]\[13\] regfile.registers\[13\]\[13\] regfile.registers\[14\]\[13\]
+ regfile.registers\[15\]\[13\] _1291_ _1194_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__mux4_1
X_8485_ net1049 net25 _4216_ VGND VGND VPWR VPWR _4225_ sky130_fd_sc_hd__mux2_1
X_7436_ _3669_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4648_ regfile.registers\[24\]\[7\] regfile.registers\[25\]\[7\] regfile.registers\[26\]\[7\]
+ regfile.registers\[27\]\[7\] _1104_ _1105_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold730 regfile.registers\[8\]\[6\] VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dlygate4sd3_1
X_9106_ clknet_leaf_46_CLK _0266_ VGND VGND VPWR VPWR regfile.registers\[27\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_4579_ regfile.registers\[24\]\[30\] regfile.registers\[25\]\[30\] regfile.registers\[26\]\[30\]
+ regfile.registers\[27\]\[30\] _1267_ _1268_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__mux4_1
Xhold741 regfile.registers\[26\]\[30\] VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlygate4sd3_1
X_7367_ _3632_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
Xhold752 regfile.registers\[19\]\[5\] VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlygate4sd3_1
Xhold763 regfile.registers\[4\]\[14\] VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlygate4sd3_1
Xhold796 regfile.registers\[1\]\[26\] VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__dlygate4sd3_1
X_7298_ _3031_ net608 _3591_ VGND VGND VPWR VPWR _3596_ sky130_fd_sc_hd__mux2_1
X_6318_ _3031_ net920 _3023_ VGND VGND VPWR VPWR _3032_ sky130_fd_sc_hd__mux2_1
Xhold785 regfile.registers\[20\]\[0\] VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dlygate4sd3_1
Xhold774 regfile.registers\[25\]\[16\] VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlygate4sd3_1
X_6249_ _1148_ _1925_ VGND VGND VPWR VPWR _2975_ sky130_fd_sc_hd__nand2_1
X_9037_ clknet_leaf_11_CLK _0197_ VGND VGND VPWR VPWR regfile.registers\[31\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold90 regfile.registers\[7\]\[5\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
X_5620_ _2105_ _2356_ _2374_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_109_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5551_ _1799_ _2306_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4502_ regfile.registers\[16\]\[21\] regfile.registers\[17\]\[21\] regfile.registers\[18\]\[21\]
+ regfile.registers\[19\]\[21\] _1220_ _1222_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__mux4_2
XFILLER_0_5_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8270_ _4111_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_111_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5482_ regfile.registers\[12\]\[9\] regfile.registers\[13\]\[9\] regfile.registers\[14\]\[9\]
+ regfile.registers\[15\]\[9\] _1782_ _1680_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__mux4_1
X_7221_ _3554_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4433_ _1048_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_41_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7152_ _3509_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
X_4364_ _1047_ _1119_ _1050_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__o21a_1
X_6103_ _1446_ _2836_ VGND VGND VPWR VPWR _2837_ sky130_fd_sc_hd__xnor2_1
X_7083_ net557 _3124_ _3460_ VGND VGND VPWR VPWR _3466_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4295_ _1048_ _1049_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__o21a_1
X_6034_ _1874_ _2743_ _2762_ _1858_ VGND VGND VPWR VPWR _2772_ sky130_fd_sc_hd__o22a_1
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer11 _1416_ VGND VGND VPWR VPWR net1139 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_68_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer22 _1348_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer33 _2506_ VGND VGND VPWR VPWR net1142 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7985_ _3107_ net406 _3952_ VGND VGND VPWR VPWR _3960_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6936_ net147 _3113_ _3387_ VGND VGND VPWR VPWR _3388_ sky130_fd_sc_hd__mux2_1
XFILLER_0_119_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6867_ _3339_ VGND VGND VPWR VPWR _3351_ sky130_fd_sc_hd__buf_4
X_5818_ _2525_ _2566_ _1146_ VGND VGND VPWR VPWR _2567_ sky130_fd_sc_hd__mux2_1
X_9586_ clknet_leaf_45_CLK _0746_ VGND VGND VPWR VPWR regfile.registers\[10\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_6798_ _3302_ VGND VGND VPWR VPWR _3314_ sky130_fd_sc_hd__clkbuf_8
X_8606_ clknet_leaf_70_CLK _0790_ VGND VGND VPWR VPWR regfile.registers\[17\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5749_ _1126_ VGND VGND VPWR VPWR _2501_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8537_ net937 net18 _4244_ VGND VGND VPWR VPWR _4252_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_79_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8468_ _4204_ VGND VGND VPWR VPWR _4216_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_60_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7419_ _3659_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_92_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8399_ _4179_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold560 regfile.registers\[10\]\[12\] VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__dlygate4sd3_1
Xhold571 regfile.registers\[15\]\[7\] VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_102_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold593 regfile.registers\[7\]\[14\] VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__dlygate4sd3_1
Xhold582 regfile.registers\[27\]\[6\] VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput80 net80 VGND VGND VPWR VPWR ALUResult[9] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4982_ _1684_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__buf_4
X_7770_ _3846_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6721_ _3273_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__clkbuf_1
X_6652_ _3033_ net470 _3231_ VGND VGND VPWR VPWR _3237_ sky130_fd_sc_hd__mux2_1
X_9440_ clknet_leaf_76_CLK _0600_ VGND VGND VPWR VPWR regfile.registers\[13\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_9371_ clknet_leaf_27_CLK _0531_ VGND VGND VPWR VPWR regfile.registers\[20\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_5603_ _1839_ _2230_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8322_ net927 _3502_ _4133_ VGND VGND VPWR VPWR _4139_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6583_ net974 _3103_ _3194_ VGND VGND VPWR VPWR _3200_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5534_ regfile.registers\[20\]\[4\] regfile.registers\[21\]\[4\] regfile.registers\[22\]\[4\]
+ regfile.registers\[23\]\[4\] _2050_ _2052_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__mux4_1
XFILLER_0_26_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_115_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5465_ regfile.registers\[8\]\[8\] regfile.registers\[9\]\[8\] regfile.registers\[10\]\[8\]
+ regfile.registers\[11\]\[8\] _1719_ _1722_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__mux4_1
X_8253_ _4102_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__clkbuf_1
X_7204_ net1017 _3544_ _3534_ VGND VGND VPWR VPWR _3545_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8184_ net1089 _3500_ _4061_ VGND VGND VPWR VPWR _4066_ sky130_fd_sc_hd__mux2_1
X_4416_ _1072_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_74_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7135_ net41 VGND VGND VPWR VPWR _3498_ sky130_fd_sc_hd__buf_2
X_5396_ regfile.registers\[4\]\[13\] regfile.registers\[5\]\[13\] regfile.registers\[6\]\[13\]
+ regfile.registers\[7\]\[13\] _1702_ _1678_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_74_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4347_ regfile.registers\[4\]\[3\] regfile.registers\[5\]\[3\] regfile.registers\[6\]\[3\]
+ regfile.registers\[7\]\[3\] _1089_ _1090_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__mux4_1
X_7066_ net690 _3107_ _3449_ VGND VGND VPWR VPWR _3457_ sky130_fd_sc_hd__mux2_1
X_4278_ net6 VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__inv_2
X_6017_ _2565_ _2609_ _1148_ VGND VGND VPWR VPWR _2756_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7968_ _3950_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7899_ net1126 _3488_ _3879_ VGND VGND VPWR VPWR _3914_ sky130_fd_sc_hd__mux2_1
X_6919_ net277 _3097_ _3376_ VGND VGND VPWR VPWR _3379_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9569_ clknet_leaf_82_CLK _0729_ VGND VGND VPWR VPWR regfile.registers\[10\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold390 regfile.registers\[15\]\[5\] VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 net81 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dlymetal6s2s_1
X_5250_ _2002_ _2005_ _1700_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__mux2_1
X_5181_ _1745_ _1936_ _1697_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_110_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8940_ clknet_leaf_0_CLK _0100_ VGND VGND VPWR VPWR regfile.registers\[3\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8871_ clknet_leaf_57_CLK _0031_ VGND VGND VPWR VPWR regfile.registers\[4\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_7822_ _3873_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__clkbuf_1
X_7753_ _3077_ net886 _3830_ VGND VGND VPWR VPWR _3837_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4965_ _1678_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__buf_4
X_6704_ _3085_ net694 _3230_ VGND VGND VPWR VPWR _3264_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7684_ _3800_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9423_ clknet_leaf_1_CLK _0583_ VGND VGND VPWR VPWR regfile.registers\[1\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_4896_ regfile.registers\[12\]\[0\] regfile.registers\[13\]\[0\] regfile.registers\[14\]\[0\]
+ regfile.registers\[15\]\[0\] _1641_ _1642_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_50_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6635_ net232 _3015_ _3193_ VGND VGND VPWR VPWR _3227_ sky130_fd_sc_hd__mux2_1
X_6566_ _3087_ net738 _3154_ VGND VGND VPWR VPWR _3189_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9354_ clknet_leaf_107_CLK _0514_ VGND VGND VPWR VPWR regfile.registers\[20\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8305_ _4129_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5517_ regfile.registers\[24\]\[7\] regfile.registers\[25\]\[7\] regfile.registers\[26\]\[7\]
+ regfile.registers\[27\]\[7\] _2051_ _2053_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__mux4_1
X_9285_ clknet_leaf_66_CLK _0445_ VGND VGND VPWR VPWR regfile.registers\[25\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_8236_ net200 _3484_ _4083_ VGND VGND VPWR VPWR _4093_ sky130_fd_sc_hd__mux2_1
X_6497_ net820 _3017_ _3092_ VGND VGND VPWR VPWR _3152_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5448_ _2202_ _2203_ _1711_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__mux2_1
X_8167_ _4056_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5379_ _1699_ _2134_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__nand2_1
X_8098_ net647 _3482_ _4011_ VGND VGND VPWR VPWR _4020_ sky130_fd_sc_hd__mux2_1
X_7118_ net39 VGND VGND VPWR VPWR _3486_ sky130_fd_sc_hd__buf_2
X_7049_ net10 net9 net48 VGND VGND VPWR VPWR _3447_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4750_ _1214_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4681_ _1433_ _1436_ _1187_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__mux2_2
XFILLER_0_83_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6420_ net119 _3101_ _3093_ VGND VGND VPWR VPWR _3102_ sky130_fd_sc_hd__mux2_1
X_6351_ net22 VGND VGND VPWR VPWR _3054_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_101_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5302_ regfile.registers\[4\]\[3\] regfile.registers\[5\]\[3\] regfile.registers\[6\]\[3\]
+ regfile.registers\[7\]\[3\] _1703_ _1706_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__mux4_1
X_6282_ _3003_ _3005_ VGND VGND VPWR VPWR _3006_ sky130_fd_sc_hd__nor2_4
XFILLER_0_59_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9070_ clknet_leaf_3_CLK _0230_ VGND VGND VPWR VPWR regfile.registers\[26\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_8021_ _3143_ net490 _3974_ VGND VGND VPWR VPWR _3979_ sky130_fd_sc_hd__mux2_1
XFILLER_0_121_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5233_ regfile.registers\[8\]\[26\] regfile.registers\[9\]\[26\] regfile.registers\[10\]\[26\]
+ regfile.registers\[11\]\[26\] _1896_ _1898_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5164_ regfile.registers\[0\]\[30\] regfile.registers\[1\]\[30\] regfile.registers\[2\]\[30\]
+ regfile.registers\[3\]\[30\] _1918_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_71_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5095_ regfile.registers\[12\]\[17\] regfile.registers\[13\]\[17\] regfile.registers\[14\]\[17\]
+ regfile.registers\[15\]\[17\] _1720_ _1723_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__mux4_1
X_8923_ clknet_leaf_27_CLK _0083_ VGND VGND VPWR VPWR regfile.registers\[19\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclone7 A2[0] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_16
X_8854_ clknet_leaf_54_CLK _0014_ VGND VGND VPWR VPWR regfile.registers\[5\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_123_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7805_ _3864_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__clkbuf_1
X_5997_ _1060_ _1085_ VGND VGND VPWR VPWR _2737_ sky130_fd_sc_hd__nor2b_2
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8785_ clknet_leaf_19_CLK _0969_ VGND VGND VPWR VPWR regfile.registers\[14\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4948_ _1703_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__buf_4
X_7736_ _3060_ net1093 _3819_ VGND VGND VPWR VPWR _3828_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4879_ _1602_ _1618_ _1634_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7667_ _3791_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__clkbuf_1
X_6618_ _3218_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__clkbuf_1
X_9406_ clknet_leaf_71_CLK _0566_ VGND VGND VPWR VPWR regfile.registers\[1\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7598_ _3058_ net844 _3747_ VGND VGND VPWR VPWR _3755_ sky130_fd_sc_hd__mux2_1
X_9337_ clknet_leaf_37_CLK _0497_ VGND VGND VPWR VPWR regfile.registers\[21\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6549_ _3180_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__clkbuf_1
X_9268_ clknet_leaf_23_CLK _0428_ VGND VGND VPWR VPWR regfile.registers\[18\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8219_ _4084_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9199_ clknet_leaf_2_CLK _0359_ VGND VGND VPWR VPWR regfile.registers\[30\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_113_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_122_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5920_ _2633_ _2642_ _2643_ VGND VGND VPWR VPWR _2664_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5851_ _2562_ _2560_ _2559_ VGND VGND VPWR VPWR _2599_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8570_ clknet_leaf_24_CLK _0754_ VGND VGND VPWR VPWR regfile.registers\[10\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_5782_ _2530_ _2531_ _2532_ _2373_ VGND VGND VPWR VPWR _2533_ sky130_fd_sc_hd__o211a_1
XFILLER_0_61_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4802_ _1024_ _1549_ _1553_ _1557_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__a2bb2o_4
XTAP_TAPCELL_ROW_32_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7521_ _3714_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
X_4733_ _1287_ _1488_ _1078_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7452_ _3048_ net934 _3675_ VGND VGND VPWR VPWR _3678_ sky130_fd_sc_hd__mux2_1
X_4664_ regfile.registers\[20\]\[23\] regfile.registers\[21\]\[23\] regfile.registers\[22\]\[23\]
+ regfile.registers\[23\]\[23\] _1351_ _1352_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__mux4_1
XFILLER_0_114_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6403_ net16 VGND VGND VPWR VPWR _3089_ sky130_fd_sc_hd__buf_2
X_4595_ _1324_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__buf_4
Xhold901 regfile.registers\[22\]\[22\] VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7383_ _3048_ net1094 _3638_ VGND VGND VPWR VPWR _3641_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold912 regfile.registers\[8\]\[0\] VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_114_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6334_ _3042_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9122_ clknet_leaf_86_CLK _0282_ VGND VGND VPWR VPWR regfile.registers\[28\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold934 regfile.registers\[19\]\[3\] VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__dlygate4sd3_1
Xhold923 regfile.registers\[19\]\[11\] VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__dlygate4sd3_1
Xhold945 regfile.registers\[30\]\[17\] VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__dlygate4sd3_1
X_6265_ _2966_ _2980_ _2408_ _2990_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__o2bb2a_2
Xhold967 regfile.registers\[23\]\[9\] VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__dlygate4sd3_1
X_9053_ clknet_leaf_10_CLK _0213_ VGND VGND VPWR VPWR regfile.registers\[31\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold989 regfile.registers\[27\]\[1\] VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__dlygate4sd3_1
Xhold956 regfile.registers\[29\]\[17\] VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__dlygate4sd3_1
Xhold978 regfile.registers\[22\]\[17\] VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__dlygate4sd3_1
X_5216_ _1970_ _1971_ _1889_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__mux2_1
X_8004_ _3126_ net878 _3963_ VGND VGND VPWR VPWR _3970_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6196_ _2895_ _2924_ _2363_ VGND VGND VPWR VPWR _2925_ sky130_fd_sc_hd__mux2_1
X_5147_ _1766_ _1902_ _1672_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__o21ai_1
X_5078_ regfile.registers\[4\]\[19\] regfile.registers\[5\]\[19\] regfile.registers\[6\]\[19\]
+ regfile.registers\[7\]\[19\] _1704_ _1707_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8906_ clknet_leaf_107_CLK _0066_ VGND VGND VPWR VPWR regfile.registers\[19\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_84_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8837_ clknet_leaf_93_CLK _1021_ VGND VGND VPWR VPWR regfile.registers\[5\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_8768_ clknet_leaf_81_CLK _0952_ VGND VGND VPWR VPWR regfile.registers\[14\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_7719_ _3807_ VGND VGND VPWR VPWR _3819_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_124_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8699_ clknet_leaf_42_CLK _0883_ VGND VGND VPWR VPWR regfile.registers\[0\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold208 regfile.registers\[19\]\[12\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold219 regfile.registers\[10\]\[29\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
X_4380_ regfile.registers\[8\]\[1\] regfile.registers\[9\]\[1\] regfile.registers\[10\]\[1\]
+ regfile.registers\[11\]\[1\] net98 _1053_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_55_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6050_ _2785_ _2774_ _2786_ VGND VGND VPWR VPWR _2787_ sky130_fd_sc_hd__a21oi_1
X_5001_ _1669_ _1732_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__a21bo_1
X_6952_ net1044 _3130_ _3387_ VGND VGND VPWR VPWR _3396_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5903_ _2567_ VGND VGND VPWR VPWR _2648_ sky130_fd_sc_hd__inv_2
X_6883_ _3359_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5834_ _2581_ VGND VGND VPWR VPWR _2582_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_66_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8622_ clknet_leaf_4_CLK _0806_ VGND VGND VPWR VPWR regfile.registers\[17\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_45_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5765_ _2323_ _2515_ VGND VGND VPWR VPWR _2516_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8553_ _4260_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5696_ _1667_ _1660_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7504_ _3705_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4716_ regfile.registers\[8\]\[13\] regfile.registers\[9\]\[13\] regfile.registers\[10\]\[13\]
+ regfile.registers\[11\]\[13\] _1291_ _1194_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__mux4_1
X_8484_ _4224_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__clkbuf_1
X_4647_ regfile.registers\[28\]\[7\] regfile.registers\[29\]\[7\] regfile.registers\[30\]\[7\]
+ regfile.registers\[31\]\[7\] _1104_ _1105_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__mux4_1
X_7435_ _3031_ net650 _3664_ VGND VGND VPWR VPWR _3669_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7366_ _3031_ net579 _3627_ VGND VGND VPWR VPWR _3632_ sky130_fd_sc_hd__mux2_1
Xhold720 regfile.registers\[8\]\[2\] VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlygate4sd3_1
X_4578_ _1171_ _1323_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__a21o_1
Xhold753 regfile.registers\[24\]\[8\] VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlygate4sd3_1
X_9105_ clknet_leaf_5_CLK _0265_ VGND VGND VPWR VPWR regfile.registers\[27\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6317_ net42 VGND VGND VPWR VPWR _3031_ sky130_fd_sc_hd__clkbuf_2
Xhold742 regfile.registers\[12\]\[3\] VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlygate4sd3_1
Xhold731 regfile.registers\[13\]\[12\] VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlygate4sd3_1
Xhold764 regfile.registers\[28\]\[17\] VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlygate4sd3_1
Xhold775 regfile.registers\[21\]\[29\] VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
X_7297_ _3595_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
Xhold797 regfile.registers\[22\]\[18\] VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlygate4sd3_1
Xhold786 regfile.registers\[30\]\[16\] VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlygate4sd3_1
X_6248_ _2969_ _2973_ _2530_ VGND VGND VPWR VPWR _2974_ sky130_fd_sc_hd__mux2_2
X_9036_ clknet_leaf_109_CLK _0196_ VGND VGND VPWR VPWR regfile.registers\[31\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_6179_ _2017_ _1998_ VGND VGND VPWR VPWR _2909_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_90_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold91 regfile.registers\[7\]\[28\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 regfile.registers\[3\]\[15\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_58_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5550_ _1842_ _2305_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4501_ regfile.registers\[20\]\[21\] regfile.registers\[21\]\[21\] regfile.registers\[22\]\[21\]
+ regfile.registers\[23\]\[21\] _1220_ _1222_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__mux4_2
XFILLER_0_81_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5481_ _2233_ _2236_ _1828_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4432_ _1179_ _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__mux2_4
X_7220_ net169 _3490_ _3553_ VGND VGND VPWR VPWR _3554_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_117_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7151_ net399 _3508_ _3492_ VGND VGND VPWR VPWR _3509_ sky130_fd_sc_hd__mux2_1
X_4363_ regfile.registers\[0\]\[2\] regfile.registers\[1\]\[2\] regfile.registers\[2\]\[2\]
+ regfile.registers\[3\]\[2\] net87 _1061_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__mux4_1
XFILLER_0_111_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6102_ _1512_ _2835_ _1635_ _2658_ _2536_ VGND VGND VPWR VPWR _2836_ sky130_fd_sc_hd__a41o_1
X_7082_ _3465_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
X_4294_ net7 VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__clkinv_4
X_6033_ _2770_ VGND VGND VPWR VPWR _2771_ sky130_fd_sc_hd__inv_2
Xrebuffer12 net93 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_68_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer23 net102 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer34 _2657_ VGND VGND VPWR VPWR net1143 sky130_fd_sc_hd__buf_6
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7984_ _3959_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6935_ _3375_ VGND VGND VPWR VPWR _3387_ sky130_fd_sc_hd__buf_4
XFILLER_0_49_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6866_ _3350_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__clkbuf_1
X_5817_ _2565_ VGND VGND VPWR VPWR _2566_ sky130_fd_sc_hd__inv_2
X_9585_ clknet_leaf_19_CLK _0745_ VGND VGND VPWR VPWR regfile.registers\[10\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_8605_ clknet_leaf_11_CLK _0789_ VGND VGND VPWR VPWR regfile.registers\[23\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_6797_ _3313_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5748_ _2418_ _2499_ _1147_ VGND VGND VPWR VPWR _2500_ sky130_fd_sc_hd__mux2_1
X_8536_ _4251_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5679_ _2307_ _2325_ _1148_ VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__a21oi_1
X_8467_ _4215_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7418_ _3083_ net999 _3649_ VGND VGND VPWR VPWR _3659_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_92_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8398_ net538 _3510_ _4169_ VGND VGND VPWR VPWR _4179_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7349_ _3622_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
Xhold561 regfile.registers\[11\]\[9\] VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__dlygate4sd3_1
Xhold572 regfile.registers\[31\]\[5\] VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dlygate4sd3_1
Xhold550 regfile.registers\[8\]\[17\] VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__dlygate4sd3_1
Xhold583 regfile.registers\[8\]\[7\] VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dlygate4sd3_1
Xhold594 regfile.registers\[1\]\[7\] VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__dlygate4sd3_1
X_9019_ clknet_leaf_26_CLK _0179_ VGND VGND VPWR VPWR regfile.registers\[29\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput70 net70 VGND VGND VPWR VPWR ALUResult[29] sky130_fd_sc_hd__buf_8
XTAP_TAPCELL_ROW_8_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4981_ regfile.registers\[16\]\[22\] regfile.registers\[17\]\[22\] regfile.registers\[18\]\[22\]
+ regfile.registers\[19\]\[22\] _1734_ _1735_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__mux4_1
XFILLER_0_86_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6720_ net1028 _3103_ _3267_ VGND VGND VPWR VPWR _3273_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6651_ _3236_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__clkbuf_1
X_9370_ clknet_leaf_23_CLK _0530_ VGND VGND VPWR VPWR regfile.registers\[20\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_5602_ _1667_ _2287_ VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6582_ _3199_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5533_ _1169_ _2272_ _2288_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__a21oi_1
X_8321_ _4138_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5464_ _2216_ _2219_ _1699_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__mux2_1
X_8252_ _3101_ net951 _4097_ VGND VGND VPWR VPWR _4102_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7203_ net33 VGND VGND VPWR VPWR _3544_ sky130_fd_sc_hd__buf_2
X_4415_ _1170_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__clkbuf_8
X_5395_ _2147_ _2150_ net4 VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8183_ _4065_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_111_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7134_ _3497_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
X_4346_ _1071_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_74_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4277_ regfile.registers\[24\]\[4\] regfile.registers\[25\]\[4\] regfile.registers\[26\]\[4\]
+ regfile.registers\[27\]\[4\] _1027_ _1029_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__mux4_1
X_7065_ _3456_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
X_6016_ _2496_ _2754_ VGND VGND VPWR VPWR _2755_ sky130_fd_sc_hd__and2_1
X_7967_ _3017_ net592 _3915_ VGND VGND VPWR VPWR _3950_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7898_ _3913_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__clkbuf_1
X_6918_ _3378_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6849_ net784 _3095_ _3340_ VGND VGND VPWR VPWR _3342_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9568_ clknet_leaf_75_CLK _0728_ VGND VGND VPWR VPWR regfile.registers\[10\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_122_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9499_ clknet_leaf_31_CLK _0659_ VGND VGND VPWR VPWR regfile.registers\[16\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_72_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8519_ _4242_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold380 regfile.registers\[9\]\[27\] VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold391 regfile.registers\[4\]\[6\] VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer3 _2506_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5180_ regfile.registers\[0\]\[29\] regfile.registers\[1\]\[29\] regfile.registers\[2\]\[29\]
+ regfile.registers\[3\]\[29\] _1895_ _1897_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__mux4_1
XFILLER_0_48_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8870_ clknet_leaf_55_CLK _0030_ VGND VGND VPWR VPWR regfile.registers\[4\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_125_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7821_ net422 _3478_ _3866_ VGND VGND VPWR VPWR _3873_ sky130_fd_sc_hd__mux2_1
X_7752_ _3836_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__clkbuf_1
X_4964_ _1719_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__clkbuf_8
X_6703_ _3263_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7683_ net260 _3544_ _3794_ VGND VGND VPWR VPWR _3800_ sky130_fd_sc_hd__mux2_1
XFILLER_0_104_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4895_ regfile.registers\[8\]\[0\] regfile.registers\[9\]\[0\] regfile.registers\[10\]\[0\]
+ regfile.registers\[11\]\[0\] _1641_ _1642_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__mux4_1
X_9422_ clknet_leaf_7_CLK _0582_ VGND VGND VPWR VPWR regfile.registers\[1\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6634_ _3226_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6565_ _3188_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__clkbuf_1
X_9353_ clknet_leaf_103_CLK _0513_ VGND VGND VPWR VPWR regfile.registers\[20\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8304_ _3013_ net814 _4119_ VGND VGND VPWR VPWR _4129_ sky130_fd_sc_hd__mux2_1
X_6496_ _3151_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__clkbuf_1
X_5516_ _1638_ _2271_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_76_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9284_ clknet_leaf_92_CLK _0444_ VGND VGND VPWR VPWR regfile.registers\[25\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_100_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8235_ _4092_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5447_ regfile.registers\[12\]\[10\] regfile.registers\[13\]\[10\] regfile.registers\[14\]\[10\]
+ regfile.registers\[15\]\[10\] _2117_ _2118_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__mux4_1
X_8166_ net1008 _3482_ _4047_ VGND VGND VPWR VPWR _4056_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5378_ _2132_ _2133_ _1711_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__mux2_1
X_7117_ _3485_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
X_8097_ _4019_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__clkbuf_1
X_4329_ net14 _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__nor2_1
X_7048_ _3446_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8999_ clknet_leaf_62_CLK _0159_ VGND VGND VPWR VPWR regfile.registers\[29\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4680_ _1434_ _1435_ _1178_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6350_ _3053_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_113_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5301_ _1828_ _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__nor2_1
X_6281_ net9 _3004_ VGND VGND VPWR VPWR _3005_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_58_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8020_ _3978_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5232_ regfile.registers\[12\]\[26\] regfile.registers\[13\]\[26\] regfile.registers\[14\]\[26\]
+ regfile.registers\[15\]\[26\] _1896_ _1898_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5163_ _1823_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_71_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5094_ regfile.registers\[8\]\[17\] regfile.registers\[9\]\[17\] regfile.registers\[10\]\[17\]
+ regfile.registers\[11\]\[17\] _1720_ _1723_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__mux4_1
X_8922_ clknet_leaf_25_CLK _0082_ VGND VGND VPWR VPWR regfile.registers\[19\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8853_ clknet_leaf_31_CLK _0013_ VGND VGND VPWR VPWR regfile.registers\[5\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7804_ net434 _3529_ _3855_ VGND VGND VPWR VPWR _3864_ sky130_fd_sc_hd__mux2_1
X_5996_ _2733_ _2735_ _1879_ VGND VGND VPWR VPWR _2736_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8784_ clknet_leaf_6_CLK _0968_ VGND VGND VPWR VPWR regfile.registers\[14\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4947_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7735_ _3827_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__clkbuf_1
X_4878_ _1239_ _1625_ _1629_ _1633_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_7_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7666_ net544 _3527_ _3783_ VGND VGND VPWR VPWR _3791_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6617_ net312 _3137_ _3216_ VGND VGND VPWR VPWR _3218_ sky130_fd_sc_hd__mux2_1
XFILLER_0_105_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9405_ clknet_leaf_12_CLK _0565_ VGND VGND VPWR VPWR regfile.registers\[24\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9336_ clknet_leaf_21_CLK _0496_ VGND VGND VPWR VPWR regfile.registers\[21\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_7597_ _3754_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
X_6548_ _3069_ net981 _3177_ VGND VGND VPWR VPWR _3180_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6479_ net294 _3141_ _3135_ VGND VGND VPWR VPWR _3142_ sky130_fd_sc_hd__mux2_1
X_9267_ clknet_leaf_28_CLK _0427_ VGND VGND VPWR VPWR regfile.registers\[18\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_8218_ net140 _3533_ _4083_ VGND VGND VPWR VPWR _4084_ sky130_fd_sc_hd__mux2_1
X_9198_ clknet_leaf_3_CLK _0358_ VGND VGND VPWR VPWR regfile.registers\[30\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_8149_ _4024_ VGND VGND VPWR VPWR _4047_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_750 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5850_ _2229_ _2597_ VGND VGND VPWR VPWR _2598_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5781_ _2255_ _2355_ _2364_ _2337_ VGND VGND VPWR VPWR _2532_ sky130_fd_sc_hd__o22a_1
XFILLER_0_61_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4801_ _1088_ _1556_ net8 VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_32_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7520_ _3048_ net879 _3711_ VGND VGND VPWR VPWR _3714_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4732_ regfile.registers\[0\]\[14\] regfile.registers\[1\]\[14\] regfile.registers\[2\]\[14\]
+ regfile.registers\[3\]\[14\] _1191_ _1174_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__mux4_1
X_4663_ regfile.registers\[16\]\[23\] regfile.registers\[17\]\[23\] regfile.registers\[18\]\[23\]
+ regfile.registers\[19\]\[23\] _1351_ _1352_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__mux4_1
X_7451_ _3677_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
X_6402_ _3088_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4594_ _1238_ _1278_ _1316_ _1349_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__or4_1
Xhold902 regfile.registers\[26\]\[31\] VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__dlygate4sd3_1
X_7382_ _3640_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold913 regfile.registers\[10\]\[13\] VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__dlygate4sd3_1
Xhold935 regfile.registers\[29\]\[29\] VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__dlygate4sd3_1
X_6333_ _3041_ net1047 _3023_ VGND VGND VPWR VPWR _3042_ sky130_fd_sc_hd__mux2_1
Xhold924 regfile.registers\[21\]\[1\] VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__dlygate4sd3_1
X_9121_ clknet_leaf_84_CLK _0281_ VGND VGND VPWR VPWR regfile.registers\[28\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold946 regfile.registers\[26\]\[7\] VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__dlygate4sd3_1
X_6264_ _2988_ _2989_ VGND VGND VPWR VPWR _2990_ sky130_fd_sc_hd__nor2_1
X_9052_ clknet_leaf_41_CLK _0212_ VGND VGND VPWR VPWR regfile.registers\[31\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold957 regfile.registers\[25\]\[9\] VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__dlygate4sd3_1
Xhold968 regfile.registers\[28\]\[19\] VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__dlygate4sd3_1
Xhold979 regfile.registers\[9\]\[6\] VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__dlygate4sd3_1
X_5215_ regfile.registers\[12\]\[27\] regfile.registers\[13\]\[27\] regfile.registers\[14\]\[27\]
+ regfile.registers\[15\]\[27\] _1918_ _1919_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__mux4_1
X_8003_ _3969_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__clkbuf_1
X_6195_ _2923_ _2384_ VGND VGND VPWR VPWR _2924_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5146_ _1899_ _1900_ _1901_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__mux2_1
X_5077_ _1700_ _1832_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__nand2_1
X_8905_ clknet_leaf_99_CLK _0065_ VGND VGND VPWR VPWR regfile.registers\[19\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_84_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8836_ clknet_leaf_91_CLK _1020_ VGND VGND VPWR VPWR regfile.registers\[5\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_5979_ _2569_ _2719_ _2104_ VGND VGND VPWR VPWR _2720_ sky130_fd_sc_hd__mux2_1
X_8767_ clknet_leaf_81_CLK _0951_ VGND VGND VPWR VPWR regfile.registers\[14\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7718_ _3818_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__clkbuf_1
X_8698_ clknet_leaf_40_CLK _0882_ VGND VGND VPWR VPWR regfile.registers\[0\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_7649_ net371 _3510_ _3772_ VGND VGND VPWR VPWR _3782_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9319_ clknet_leaf_59_CLK _0479_ VGND VGND VPWR VPWR regfile.registers\[21\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_101_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold209 regfile.registers\[2\]\[15\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_55_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5000_ _1668_ _1755_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__or2_1
X_6951_ _3395_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
X_5902_ _2644_ _2646_ VGND VGND VPWR VPWR _2647_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6882_ net241 _3128_ _3351_ VGND VGND VPWR VPWR _3359_ sky130_fd_sc_hd__mux2_1
X_5833_ _2230_ _2580_ _1839_ VGND VGND VPWR VPWR _2581_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8621_ clknet_leaf_94_CLK _0805_ VGND VGND VPWR VPWR regfile.registers\[17\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_45_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8552_ net987 net25 _4255_ VGND VGND VPWR VPWR _4260_ sky130_fd_sc_hd__mux2_1
X_5764_ _1083_ _2514_ VGND VGND VPWR VPWR _2515_ sky130_fd_sc_hd__xnor2_1
X_7503_ _3031_ net894 _3700_ VGND VGND VPWR VPWR _3705_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5695_ _2080_ _2448_ VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__xor2_1
X_4715_ _1467_ _1470_ _1071_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__mux2_1
X_8483_ net402 net24 _4216_ VGND VGND VPWR VPWR _4224_ sky130_fd_sc_hd__mux2_1
X_4646_ _1400_ _1401_ _1107_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__mux2_1
X_7434_ _3668_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4577_ _1327_ _1329_ _1332_ _1187_ _1215_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__o221a_1
X_7365_ _3631_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
Xhold721 regfile.registers\[16\]\[14\] VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlygate4sd3_1
Xhold710 regfile.registers\[14\]\[10\] VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_114_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_3__f_CLK clknet_0_CLK VGND VGND VPWR VPWR clknet_3_3__leaf_CLK sky130_fd_sc_hd__clkbuf_16
Xhold754 regfile.registers\[6\]\[28\] VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold743 regfile.registers\[9\]\[8\] VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlygate4sd3_1
Xhold732 regfile.registers\[29\]\[31\] VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlygate4sd3_1
X_6316_ _3030_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__clkbuf_1
X_9104_ clknet_leaf_7_CLK _0264_ VGND VGND VPWR VPWR regfile.registers\[27\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold776 regfile.registers\[23\]\[29\] VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7296_ _3029_ net624 _3591_ VGND VGND VPWR VPWR _3595_ sky130_fd_sc_hd__mux2_1
Xhold787 regfile.registers\[31\]\[0\] VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlygate4sd3_1
Xhold765 regfile.registers\[16\]\[17\] VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dlygate4sd3_1
X_6247_ _2972_ VGND VGND VPWR VPWR _2973_ sky130_fd_sc_hd__inv_2
Xhold798 regfile.registers\[21\]\[16\] VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlygate4sd3_1
X_9035_ clknet_leaf_104_CLK _0195_ VGND VGND VPWR VPWR regfile.registers\[31\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_6178_ _2444_ _2864_ VGND VGND VPWR VPWR _2908_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_90_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5129_ regfile.registers\[24\]\[31\] regfile.registers\[25\]\[31\] regfile.registers\[26\]\[31\]
+ regfile.registers\[27\]\[31\] _1882_ _1884_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__mux4_1
XFILLER_0_98_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8819_ clknet_leaf_31_CLK _1003_ VGND VGND VPWR VPWR regfile.registers\[6\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold81 regfile.registers\[9\]\[24\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 regfile.registers\[6\]\[26\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 regfile.registers\[5\]\[8\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_720 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4500_ _1239_ _1246_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__o21ai_4
X_5480_ _2234_ _2235_ _1685_ VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4431_ _1071_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_41_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_1 _1057_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_117_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7150_ net46 VGND VGND VPWR VPWR _3508_ sky130_fd_sc_hd__buf_2
X_4362_ _1107_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__or2_1
X_6101_ net94 _1277_ VGND VGND VPWR VPWR _2835_ sky130_fd_sc_hd__and2_1
X_7081_ net729 _3122_ _3460_ VGND VGND VPWR VPWR _3465_ sky130_fd_sc_hd__mux2_1
X_4293_ regfile.registers\[0\]\[4\] regfile.registers\[1\]\[4\] regfile.registers\[2\]\[4\]
+ regfile.registers\[3\]\[4\] net96 _1044_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__mux4_1
X_6032_ _2744_ _2763_ VGND VGND VPWR VPWR _2770_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer13 _2712_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer35 _2633_ VGND VGND VPWR VPWR net1144 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer24 net1143 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
X_7983_ _3105_ net363 _3952_ VGND VGND VPWR VPWR _3959_ sky130_fd_sc_hd__mux2_1
X_6934_ _3386_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8604_ clknet_leaf_41_CLK _0788_ VGND VGND VPWR VPWR regfile.registers\[23\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6865_ net573 _3111_ _3340_ VGND VGND VPWR VPWR _3350_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5816_ _2361_ _2357_ VGND VGND VPWR VPWR _2565_ sky130_fd_sc_hd__and2_1
X_6796_ _3041_ net910 _3303_ VGND VGND VPWR VPWR _3313_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9584_ clknet_leaf_6_CLK _0744_ VGND VGND VPWR VPWR regfile.registers\[10\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_5747_ _2498_ VGND VGND VPWR VPWR _2499_ sky130_fd_sc_hd__inv_2
X_8535_ net748 net17 _4244_ VGND VGND VPWR VPWR _4251_ sky130_fd_sc_hd__mux2_1
XFILLER_0_115_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8466_ net641 net47 _4205_ VGND VGND VPWR VPWR _4215_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7417_ _3658_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_79_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5678_ _2083_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__inv_2
X_4629_ _1370_ _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__nand2_1
X_8397_ _4178_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_50_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_50_CLK sky130_fd_sc_hd__clkbuf_8
X_7348_ _3081_ net944 _3613_ VGND VGND VPWR VPWR _3622_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_92_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold540 regfile.registers\[4\]\[22\] VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__dlygate4sd3_1
Xhold551 regfile.registers\[21\]\[26\] VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__dlygate4sd3_1
Xhold562 regfile.registers\[14\]\[12\] VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold584 regfile.registers\[11\]\[21\] VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__dlygate4sd3_1
X_7279_ _3584_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
Xhold573 regfile.registers\[24\]\[13\] VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlygate4sd3_1
Xhold595 regfile.registers\[20\]\[17\] VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__dlygate4sd3_1
X_9018_ clknet_leaf_25_CLK _0178_ VGND VGND VPWR VPWR regfile.registers\[29\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_41_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_41_CLK sky130_fd_sc_hd__clkbuf_8
Xoutput60 net60 VGND VGND VPWR VPWR ALUResult[1] sky130_fd_sc_hd__buf_6
XFILLER_0_128_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput71 net71 VGND VGND VPWR VPWR ALUResult[2] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4980_ regfile.registers\[20\]\[22\] regfile.registers\[21\]\[22\] regfile.registers\[22\]\[22\]
+ regfile.registers\[23\]\[22\] _1734_ _1735_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_63_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6650_ _3031_ net341 _3231_ VGND VGND VPWR VPWR _3236_ sky130_fd_sc_hd__mux2_1
XFILLER_0_116_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5601_ _2348_ _2355_ _1879_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6581_ net699 _3101_ _3194_ VGND VGND VPWR VPWR _3199_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5532_ _1800_ _2287_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8320_ net398 _3500_ _4133_ VGND VGND VPWR VPWR _4138_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5463_ _2217_ _2218_ _1685_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__mux2_1
X_8251_ _4101_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__clkbuf_1
X_7202_ _3543_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_32_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_32_CLK sky130_fd_sc_hd__clkbuf_8
X_5394_ _2148_ _2149_ _1684_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__mux2_1
X_4414_ _1057_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__buf_4
X_8182_ net293 _3498_ _4061_ VGND VGND VPWR VPWR _4065_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4345_ _1099_ _1100_ _1048_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__mux2_1
X_7133_ net430 _3496_ _3492_ VGND VGND VPWR VPWR _3497_ sky130_fd_sc_hd__mux2_1
XFILLER_0_111_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4276_ regfile.registers\[28\]\[4\] regfile.registers\[29\]\[4\] regfile.registers\[30\]\[4\]
+ regfile.registers\[31\]\[4\] _1027_ _1029_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__mux4_1
X_7064_ net500 _3105_ _3449_ VGND VGND VPWR VPWR _3456_ sky130_fd_sc_hd__mux2_1
X_6015_ _2751_ _2753_ _2252_ VGND VGND VPWR VPWR _2754_ sky130_fd_sc_hd__mux2_1
XFILLER_0_94_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7966_ _3949_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_25_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_99_CLK clknet_3_1__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_99_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_92_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7897_ net420 _3486_ _3879_ VGND VGND VPWR VPWR _3913_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6917_ net616 _3095_ _3376_ VGND VGND VPWR VPWR _3378_ sky130_fd_sc_hd__mux2_1
X_6848_ _3341_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9567_ clknet_leaf_81_CLK _0727_ VGND VGND VPWR VPWR regfile.registers\[10\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_8518_ net535 net38 _3007_ VGND VGND VPWR VPWR _4242_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6779_ _3304_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__clkbuf_1
X_9498_ clknet_leaf_25_CLK _0658_ VGND VGND VPWR VPWR regfile.registers\[16\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8449_ _4206_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_23_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_23_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_32_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold381 regfile.registers\[6\]\[22\] VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__dlygate4sd3_1
Xhold370 regfile.registers\[31\]\[3\] VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd3_1
Xhold392 regfile.registers\[7\]\[29\] VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer4 _1125_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_114_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_14_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_14_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_11_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7820_ _3872_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7751_ _3075_ net527 _3830_ VGND VGND VPWR VPWR _3836_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4963_ _1718_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__clkbuf_8
X_7682_ _3799_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__clkbuf_1
X_6702_ _3083_ net838 _3253_ VGND VGND VPWR VPWR _3263_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6633_ net530 _3013_ _3216_ VGND VGND VPWR VPWR _3226_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4894_ _1646_ _1649_ net4 VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__mux2_1
X_9421_ clknet_leaf_93_CLK _0581_ VGND VGND VPWR VPWR regfile.registers\[1\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6564_ _3085_ net1116 _3154_ VGND VGND VPWR VPWR _3188_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9352_ clknet_leaf_86_CLK _0512_ VGND VGND VPWR VPWR regfile.registers\[20\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8303_ _4128_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__clkbuf_1
X_6495_ net1102 _3015_ _3092_ VGND VGND VPWR VPWR _3151_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9283_ clknet_leaf_81_CLK _0443_ VGND VGND VPWR VPWR regfile.registers\[25\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5515_ _1670_ _2262_ _2266_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__a2bb2o_2
X_8234_ net220 _3482_ _4083_ VGND VGND VPWR VPWR _4092_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5446_ regfile.registers\[8\]\[10\] regfile.registers\[9\]\[10\] regfile.registers\[10\]\[10\]
+ regfile.registers\[11\]\[10\] _1703_ _1706_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__mux4_1
XFILLER_0_112_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8165_ _4055_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5377_ regfile.registers\[12\]\[14\] regfile.registers\[13\]\[14\] regfile.registers\[14\]\[14\]
+ regfile.registers\[15\]\[14\] _2113_ _2114_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__mux4_1
X_7116_ net510 _3484_ _3471_ VGND VGND VPWR VPWR _3485_ sky130_fd_sc_hd__mux2_1
X_8096_ net603 _3480_ _4011_ VGND VGND VPWR VPWR _4019_ sky130_fd_sc_hd__mux2_1
X_4328_ net15 _1083_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__nand2_1
X_7047_ net764 _3017_ _3411_ VGND VGND VPWR VPWR _3446_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8998_ clknet_leaf_70_CLK _0158_ VGND VGND VPWR VPWR regfile.registers\[29\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_7949_ _3139_ net373 _3938_ VGND VGND VPWR VPWR _3941_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_3_CLK clknet_3_0__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_3_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_16_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5300_ _2054_ _2055_ _1712_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__mux2_1
X_6280_ net10 net48 VGND VGND VPWR VPWR _3004_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5231_ _1983_ _1986_ _1766_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__mux2_1
X_5162_ _1822_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_71_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5093_ _1845_ _1848_ _1697_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__mux2_1
X_8921_ clknet_leaf_37_CLK _0081_ VGND VGND VPWR VPWR regfile.registers\[19\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_8852_ clknet_leaf_16_CLK _0012_ VGND VGND VPWR VPWR regfile.registers\[5\]\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_7803_ _3863_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__clkbuf_1
X_8783_ clknet_leaf_3_CLK _0967_ VGND VGND VPWR VPWR regfile.registers\[14\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_5995_ _2703_ _2734_ _2347_ VGND VGND VPWR VPWR _2735_ sky130_fd_sc_hd__mux2_1
X_7734_ _3058_ net1025 _3819_ VGND VGND VPWR VPWR _3827_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4946_ _1701_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__buf_4
XFILLER_0_24_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4877_ _1254_ _1632_ _1170_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7665_ _3790_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
X_9404_ clknet_leaf_42_CLK _0564_ VGND VGND VPWR VPWR regfile.registers\[24\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_6616_ _3217_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7596_ _3056_ net917 _3747_ VGND VGND VPWR VPWR _3754_ sky130_fd_sc_hd__mux2_1
X_9335_ clknet_leaf_36_CLK _0495_ VGND VGND VPWR VPWR regfile.registers\[21\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_6547_ _3179_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6478_ net31 VGND VGND VPWR VPWR _3141_ sky130_fd_sc_hd__buf_2
X_9266_ clknet_leaf_47_CLK _0426_ VGND VGND VPWR VPWR regfile.registers\[18\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_18_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8217_ _4060_ VGND VGND VPWR VPWR _4083_ sky130_fd_sc_hd__buf_4
X_9197_ clknet_leaf_11_CLK _0357_ VGND VGND VPWR VPWR regfile.registers\[30\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5429_ regfile.registers\[12\]\[11\] regfile.registers\[13\]\[11\] regfile.registers\[14\]\[11\]
+ regfile.registers\[15\]\[11\] _1704_ _1707_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__mux4_1
X_8148_ _4046_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__clkbuf_1
X_8079_ net792 _3531_ _4000_ VGND VGND VPWR VPWR _4010_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_27_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_36_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4800_ _1554_ _1555_ _1107_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__mux2_1
X_5780_ _2403_ _2348_ _1879_ VGND VGND VPWR VPWR _2531_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4731_ _1198_ _1486_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__or2_1
X_4662_ regfile.registers\[28\]\[23\] regfile.registers\[29\]\[23\] regfile.registers\[30\]\[23\]
+ regfile.registers\[31\]\[23\] _1267_ _1268_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__mux4_1
XFILLER_0_56_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7450_ _3046_ net862 _3675_ VGND VGND VPWR VPWR _3677_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6401_ _3087_ net554 _3022_ VGND VGND VPWR VPWR _3088_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_54_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4593_ _1334_ _1348_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__or2b_1
X_7381_ _3046_ net1122 _3638_ VGND VGND VPWR VPWR _3640_ sky130_fd_sc_hd__mux2_1
X_9120_ clknet_leaf_78_CLK _0280_ VGND VGND VPWR VPWR regfile.registers\[28\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold903 regfile.registers\[14\]\[1\] VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_101_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6332_ net47 VGND VGND VPWR VPWR _3041_ sky130_fd_sc_hd__clkbuf_2
Xhold936 regfile.registers\[11\]\[10\] VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__dlygate4sd3_1
Xhold925 regfile.registers\[26\]\[0\] VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__dlygate4sd3_1
Xhold914 regfile.registers\[27\]\[18\] VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__dlygate4sd3_1
X_6263_ _2952_ _2987_ _2986_ VGND VGND VPWR VPWR _2989_ sky130_fd_sc_hd__a21oi_1
X_9051_ clknet_leaf_26_CLK _0211_ VGND VGND VPWR VPWR regfile.registers\[31\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold958 regfile.registers\[16\]\[3\] VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__dlygate4sd3_1
Xhold947 regfile.registers\[30\]\[12\] VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__dlygate4sd3_1
Xhold969 regfile.registers\[11\]\[18\] VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__dlygate4sd3_1
X_5214_ regfile.registers\[8\]\[27\] regfile.registers\[9\]\[27\] regfile.registers\[10\]\[27\]
+ regfile.registers\[11\]\[27\] _1918_ _1919_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__mux4_1
X_8002_ _3124_ net552 _3963_ VGND VGND VPWR VPWR _3969_ sky130_fd_sc_hd__mux2_1
X_6194_ _1669_ _1997_ VGND VGND VPWR VPWR _2923_ sky130_fd_sc_hd__nand2_1
X_5145_ _1726_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_63_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5076_ _1830_ _1831_ _1686_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__mux2_1
X_8904_ clknet_leaf_101_CLK _0064_ VGND VGND VPWR VPWR regfile.registers\[19\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_84_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8835_ clknet_leaf_90_CLK _1019_ VGND VGND VPWR VPWR regfile.registers\[5\]\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5978_ _2650_ _2718_ _2251_ VGND VGND VPWR VPWR _2719_ sky130_fd_sc_hd__mux2_1
X_8766_ clknet_leaf_65_CLK _0950_ VGND VGND VPWR VPWR regfile.registers\[14\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_8697_ clknet_leaf_48_CLK _0881_ VGND VGND VPWR VPWR regfile.registers\[0\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_7717_ _3041_ net1119 _3808_ VGND VGND VPWR VPWR _3818_ sky130_fd_sc_hd__mux2_1
X_4929_ _1684_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__clkbuf_8
X_7648_ _3781_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7579_ _3039_ net639 _3736_ VGND VGND VPWR VPWR _3745_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_95_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9318_ clknet_leaf_55_CLK _0478_ VGND VGND VPWR VPWR regfile.registers\[21\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9249_ clknet_leaf_83_CLK _0409_ VGND VGND VPWR VPWR regfile.registers\[18\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_106_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_104_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6950_ net396 _3128_ _3387_ VGND VGND VPWR VPWR _3395_ sky130_fd_sc_hd__mux2_1
X_5901_ net1144 _2636_ _2645_ VGND VGND VPWR VPWR _2646_ sky130_fd_sc_hd__a21oi_1
X_6881_ _3358_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_119_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5832_ _2287_ VGND VGND VPWR VPWR _2580_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_66_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8620_ clknet_leaf_109_CLK _0804_ VGND VGND VPWR VPWR regfile.registers\[17\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_45_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5763_ _1060_ net90 _2411_ VGND VGND VPWR VPWR _2514_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_45_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8551_ _4259_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__clkbuf_1
X_4714_ _1468_ _1469_ _1036_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__mux2_1
X_7502_ _3704_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5694_ _1125_ _2447_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__xnor2_1
X_8482_ _4223_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__clkbuf_1
X_4645_ regfile.registers\[16\]\[7\] regfile.registers\[17\]\[7\] regfile.registers\[18\]\[7\]
+ regfile.registers\[19\]\[7\] _1104_ _1105_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__mux4_1
X_7433_ _3029_ net848 _3664_ VGND VGND VPWR VPWR _3668_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold711 regfile.registers\[25\]\[29\] VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlygate4sd3_1
X_4576_ _1330_ _1331_ _1259_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__mux2_1
Xhold700 regfile.registers\[27\]\[16\] VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlygate4sd3_1
X_7364_ _3029_ net450 _3627_ VGND VGND VPWR VPWR _3631_ sky130_fd_sc_hd__mux2_1
Xhold744 regfile.registers\[12\]\[23\] VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlygate4sd3_1
Xhold722 regfile.registers\[23\]\[30\] VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlygate4sd3_1
Xhold755 regfile.registers\[29\]\[10\] VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlygate4sd3_1
X_6315_ _3029_ net954 _3023_ VGND VGND VPWR VPWR _3030_ sky130_fd_sc_hd__mux2_1
X_9103_ clknet_leaf_1_CLK _0263_ VGND VGND VPWR VPWR regfile.registers\[27\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold733 regfile.registers\[9\]\[0\] VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlygate4sd3_1
X_7295_ _3594_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
X_9034_ clknet_leaf_104_CLK _0194_ VGND VGND VPWR VPWR regfile.registers\[31\]\[12\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold777 regfile.registers\[4\]\[13\] VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlygate4sd3_1
Xhold766 regfile.registers\[15\]\[15\] VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dlygate4sd3_1
Xhold788 regfile.registers\[24\]\[18\] VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dlygate4sd3_1
X_6246_ _2970_ _2971_ _1126_ VGND VGND VPWR VPWR _2972_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_71_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold799 regfile.registers\[27\]\[12\] VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__dlygate4sd3_1
X_6177_ _2626_ _2797_ VGND VGND VPWR VPWR _2907_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_90_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5128_ _1883_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5059_ _1700_ _1814_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8818_ clknet_leaf_60_CLK _1002_ VGND VGND VPWR VPWR regfile.registers\[6\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8749_ clknet_leaf_92_CLK _0933_ VGND VGND VPWR VPWR regfile.registers\[8\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold82 regfile.registers\[10\]\[24\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 regfile.registers\[1\]\[20\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 regfile.registers\[3\]\[5\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold93 regfile.registers\[9\]\[12\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4430_ _1180_ _1185_ _1178_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__mux2_1
XANTENNA_2 _1194_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_117_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6100_ _2496_ _2822_ _2826_ _2834_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__a211o_1
X_4361_ regfile.registers\[4\]\[2\] regfile.registers\[5\]\[2\] regfile.registers\[6\]\[2\]
+ regfile.registers\[7\]\[2\] net91 _1066_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__mux4_1
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7080_ _3464_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
X_4292_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__buf_4
X_6031_ _1820_ _2768_ VGND VGND VPWR VPWR _2769_ sky130_fd_sc_hd__xnor2_1
Xrebuffer14 _1256_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_89_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer25 net109 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer36 _2616_ VGND VGND VPWR VPWR net1145 sky130_fd_sc_hd__dlymetal6s4s_1
X_7982_ _3958_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6933_ net123 _3111_ _3376_ VGND VGND VPWR VPWR _3386_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6864_ _3349_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__clkbuf_1
X_8603_ clknet_leaf_26_CLK _0787_ VGND VGND VPWR VPWR regfile.registers\[23\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_5815_ _2561_ _2563_ VGND VGND VPWR VPWR _2564_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6795_ _3312_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9583_ clknet_leaf_3_CLK _0743_ VGND VGND VPWR VPWR regfile.registers\[10\]\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_5746_ _2064_ _2307_ VGND VGND VPWR VPWR _2498_ sky130_fd_sc_hd__and2_1
X_8534_ _4250_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5677_ _2430_ _2289_ _2363_ VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8465_ _4214_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_20_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4628_ _1171_ _1375_ _1379_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__o2bb2a_1
X_7416_ _3081_ net702 _3649_ VGND VGND VPWR VPWR _3658_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_79_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8396_ net328 _3508_ _4169_ VGND VGND VPWR VPWR _4178_ sky130_fd_sc_hd__mux2_1
Xhold530 regfile.registers\[19\]\[10\] VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7347_ _3621_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_4559_ _1171_ _1306_ _1310_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_0_102_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold563 regfile.registers\[28\]\[28\] VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold552 regfile.registers\[7\]\[26\] VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlygate4sd3_1
Xhold541 regfile.registers\[30\]\[7\] VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7278_ net171 _3482_ _3575_ VGND VGND VPWR VPWR _3584_ sky130_fd_sc_hd__mux2_1
Xhold585 regfile.registers\[17\]\[28\] VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dlygate4sd3_1
Xhold596 regfile.registers\[24\]\[31\] VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlygate4sd3_1
Xhold574 regfile.registers\[28\]\[10\] VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9017_ clknet_leaf_35_CLK _0177_ VGND VGND VPWR VPWR regfile.registers\[29\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_6229_ _2953_ _2954_ VGND VGND VPWR VPWR _2956_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput61 net61 VGND VGND VPWR VPWR ALUResult[20] sky130_fd_sc_hd__buf_2
Xoutput50 net50 VGND VGND VPWR VPWR ALUResult[10] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR ALUResult[30] sky130_fd_sc_hd__buf_6
XFILLER_0_128_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5600_ _2351_ _2354_ _2347_ VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__mux2_1
X_6580_ _3198_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__clkbuf_1
X_5531_ _1638_ _2286_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8250_ _3099_ net1077 _4097_ VGND VGND VPWR VPWR _4101_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7201_ net126 _3542_ _3534_ VGND VGND VPWR VPWR _3543_ sky130_fd_sc_hd__mux2_1
X_5462_ regfile.registers\[24\]\[8\] regfile.registers\[25\]\[8\] regfile.registers\[26\]\[8\]
+ regfile.registers\[27\]\[8\] _2051_ _2053_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__mux4_1
XFILLER_0_112_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4413_ _1168_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__buf_2
X_5393_ regfile.registers\[24\]\[13\] regfile.registers\[25\]\[13\] regfile.registers\[26\]\[13\]
+ regfile.registers\[27\]\[13\] _1673_ _1690_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__mux4_1
X_8181_ _4064_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__clkbuf_1
X_4344_ regfile.registers\[12\]\[3\] regfile.registers\[13\]\[3\] regfile.registers\[14\]\[3\]
+ regfile.registers\[15\]\[3\] _1042_ _1044_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__mux4_1
X_7132_ net38 VGND VGND VPWR VPWR _3496_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_74_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7063_ _3455_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
X_6014_ _2717_ _2752_ _1146_ VGND VGND VPWR VPWR _2753_ sky130_fd_sc_hd__mux2_1
X_4275_ regfile.registers\[16\]\[4\] regfile.registers\[17\]\[4\] regfile.registers\[18\]\[4\]
+ regfile.registers\[19\]\[4\] net1147 _1029_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__mux4_1
X_7965_ _3015_ net346 _3915_ VGND VGND VPWR VPWR _3949_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7896_ _3912_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__clkbuf_1
X_6916_ _3377_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6847_ net180 _3089_ _3340_ VGND VGND VPWR VPWR _3341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6778_ _3019_ net629 _3303_ VGND VGND VPWR VPWR _3304_ sky130_fd_sc_hd__mux2_1
X_9566_ clknet_leaf_65_CLK _0726_ VGND VGND VPWR VPWR regfile.registers\[10\]\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5729_ _2480_ _2481_ VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__or2b_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8517_ _4241_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__clkbuf_1
X_9497_ clknet_leaf_38_CLK _0657_ VGND VGND VPWR VPWR regfile.registers\[16\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8448_ net334 net16 _4205_ VGND VGND VPWR VPWR _4206_ sky130_fd_sc_hd__mux2_1
X_8379_ _4168_ VGND VGND VPWR VPWR _4169_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_20_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold371 regfile.registers\[18\]\[14\] VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__dlygate4sd3_1
Xhold360 regfile.registers\[24\]\[16\] VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlygate4sd3_1
Xhold393 regfile.registers\[22\]\[3\] VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold382 regfile.registers\[9\]\[17\] VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer5 net1137 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_106_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_125_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7750_ _3835_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__clkbuf_1
X_4962_ _1702_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__buf_4
X_7681_ net125 _3542_ _3794_ VGND VGND VPWR VPWR _3799_ sky130_fd_sc_hd__mux2_1
X_6701_ _3262_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4893_ _1647_ _1648_ _1645_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__mux2_1
X_6632_ _3225_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9420_ clknet_leaf_1_CLK _0580_ VGND VGND VPWR VPWR regfile.registers\[1\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6563_ _3187_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9351_ clknet_leaf_59_CLK _0511_ VGND VGND VPWR VPWR regfile.registers\[20\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6494_ _3150_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__clkbuf_1
X_8302_ _3011_ net890 _4119_ VGND VGND VPWR VPWR _4128_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9282_ clknet_leaf_86_CLK _0442_ VGND VGND VPWR VPWR regfile.registers\[25\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5514_ _1828_ _2269_ _1728_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__a21oi_1
X_8233_ _4091_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__clkbuf_1
X_5445_ _2197_ _2200_ _1716_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8164_ net362 _3480_ _4047_ VGND VGND VPWR VPWR _4055_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7115_ net37 VGND VGND VPWR VPWR _3484_ sky130_fd_sc_hd__clkbuf_4
X_5376_ regfile.registers\[8\]\[14\] regfile.registers\[9\]\[14\] regfile.registers\[10\]\[14\]
+ regfile.registers\[11\]\[14\] _2113_ _2114_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__mux4_1
X_8095_ _4018_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4327_ _1025_ _1070_ _1077_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_129_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7046_ _3445_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8997_ clknet_leaf_68_CLK _0157_ VGND VGND VPWR VPWR regfile.registers\[29\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_7948_ _3940_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7879_ net226 _3536_ _3902_ VGND VGND VPWR VPWR _3904_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9549_ clknet_leaf_95_CLK _0709_ VGND VGND VPWR VPWR regfile.registers\[11\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_123_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold190 regfile.registers\[11\]\[29\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5230_ _1984_ _1985_ _1901_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_58_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5161_ regfile.registers\[4\]\[30\] regfile.registers\[5\]\[30\] regfile.registers\[6\]\[30\]
+ regfile.registers\[7\]\[30\] _1881_ _1883_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_71_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5092_ _1846_ _1847_ _1686_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__mux2_1
X_8920_ clknet_leaf_23_CLK _0080_ VGND VGND VPWR VPWR regfile.registers\[19\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8851_ clknet_leaf_33_CLK _0011_ VGND VGND VPWR VPWR regfile.registers\[5\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_5994_ _1169_ _2124_ _1875_ VGND VGND VPWR VPWR _2734_ sky130_fd_sc_hd__o21a_1
X_8782_ clknet_leaf_20_CLK _0966_ VGND VGND VPWR VPWR regfile.registers\[14\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_7802_ net462 _3527_ _3855_ VGND VGND VPWR VPWR _3863_ sky130_fd_sc_hd__mux2_1
X_4945_ net1 VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_35_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7733_ _3826_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4876_ _1630_ _1631_ _1178_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7664_ net273 _3525_ _3783_ VGND VGND VPWR VPWR _3790_ sky130_fd_sc_hd__mux2_1
X_9403_ clknet_leaf_25_CLK _0563_ VGND VGND VPWR VPWR regfile.registers\[24\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_6615_ net830 _3134_ _3216_ VGND VGND VPWR VPWR _3217_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7595_ _3753_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9334_ clknet_leaf_52_CLK _0494_ VGND VGND VPWR VPWR regfile.registers\[21\]\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_6546_ _3067_ net932 _3177_ VGND VGND VPWR VPWR _3179_ sky130_fd_sc_hd__mux2_1
X_6477_ _3140_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__clkbuf_1
X_9265_ clknet_leaf_5_CLK _0425_ VGND VGND VPWR VPWR regfile.registers\[18\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_8216_ _4082_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__clkbuf_1
X_9196_ clknet_leaf_109_CLK _0356_ VGND VGND VPWR VPWR regfile.registers\[30\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_5428_ _2180_ _2181_ _2182_ _2183_ _1712_ _1716_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__mux4_1
X_8147_ net376 _3531_ _4036_ VGND VGND VPWR VPWR _4046_ sky130_fd_sc_hd__mux2_1
X_5359_ regfile.registers\[12\]\[15\] regfile.registers\[13\]\[15\] regfile.registers\[14\]\[15\]
+ regfile.registers\[15\]\[15\] _2113_ _2114_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__mux4_1
X_8078_ _4009_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__clkbuf_1
X_7029_ net620 _3139_ _3434_ VGND VGND VPWR VPWR _3437_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_123_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_100_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4730_ regfile.registers\[4\]\[14\] regfile.registers\[5\]\[14\] regfile.registers\[6\]\[14\]
+ regfile.registers\[7\]\[14\] _1172_ _1279_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__mux4_1
XFILLER_0_124_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4661_ regfile.registers\[24\]\[23\] regfile.registers\[25\]\[23\] regfile.registers\[26\]\[23\]
+ regfile.registers\[27\]\[23\] _1351_ _1352_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__mux4_1
XFILLER_0_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6400_ net40 VGND VGND VPWR VPWR _3087_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7380_ _3639_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
X_4592_ _1339_ _1171_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__a21oi_4
X_6331_ _3040_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold904 regfile.registers\[26\]\[6\] VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__dlygate4sd3_1
Xhold937 regfile.registers\[3\]\[25\] VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__dlygate4sd3_1
Xhold915 regfile.registers\[22\]\[26\] VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold926 regfile.registers\[15\]\[10\] VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_122_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold959 regfile.registers\[27\]\[23\] VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__dlygate4sd3_1
X_6262_ _2952_ _2986_ _2987_ VGND VGND VPWR VPWR _2988_ sky130_fd_sc_hd__and3_1
X_9050_ clknet_leaf_25_CLK _0210_ VGND VGND VPWR VPWR regfile.registers\[31\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold948 regfile.registers\[8\]\[5\] VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5213_ _1965_ _1968_ _1700_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__mux2_1
X_6193_ _2254_ _2858_ VGND VGND VPWR VPWR _2922_ sky130_fd_sc_hd__or2_1
X_8001_ _3968_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__clkbuf_1
X_5144_ regfile.registers\[0\]\[31\] regfile.registers\[1\]\[31\] regfile.registers\[2\]\[31\]
+ regfile.registers\[3\]\[31\] _1896_ _1898_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__mux4_1
XFILLER_0_19_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5075_ regfile.registers\[8\]\[19\] regfile.registers\[9\]\[19\] regfile.registers\[10\]\[19\]
+ regfile.registers\[11\]\[19\] _1689_ _1693_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__mux4_1
X_8903_ clknet_leaf_62_CLK _0063_ VGND VGND VPWR VPWR regfile.registers\[19\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8834_ clknet_leaf_91_CLK _1018_ VGND VGND VPWR VPWR regfile.registers\[5\]\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_5977_ _2697_ _2717_ _1803_ VGND VGND VPWR VPWR _2718_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8765_ clknet_leaf_13_CLK _0949_ VGND VGND VPWR VPWR regfile.registers\[8\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8696_ clknet_leaf_14_CLK _0880_ VGND VGND VPWR VPWR regfile.registers\[0\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_7716_ _3817_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__clkbuf_1
X_4928_ _1645_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7647_ net306 _3508_ _3772_ VGND VGND VPWR VPWR _3781_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4859_ regfile.registers\[12\]\[19\] regfile.registers\[13\]\[19\] regfile.registers\[14\]\[19\]
+ regfile.registers\[15\]\[19\] _1173_ _1175_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_10_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7578_ _3744_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
X_9317_ clknet_leaf_67_CLK _0477_ VGND VGND VPWR VPWR regfile.registers\[21\]\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_6529_ _3050_ net1091 _3166_ VGND VGND VPWR VPWR _3170_ sky130_fd_sc_hd__mux2_1
XFILLER_0_120_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9248_ clknet_leaf_76_CLK _0408_ VGND VGND VPWR VPWR regfile.registers\[18\]\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9179_ clknet_leaf_40_CLK _0339_ VGND VGND VPWR VPWR regfile.registers\[2\]\[29\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5900_ _2210_ _2632_ VGND VGND VPWR VPWR _2645_ sky130_fd_sc_hd__nor2_1
X_6880_ net531 _3126_ _3351_ VGND VGND VPWR VPWR _3358_ sky130_fd_sc_hd__mux2_1
X_5831_ _2578_ VGND VGND VPWR VPWR _2579_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_66_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5762_ _2489_ _2494_ _2505_ _2513_ _2408_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__o32a_1
XFILLER_0_29_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8550_ net576 net24 _4255_ VGND VGND VPWR VPWR _4259_ sky130_fd_sc_hd__mux2_1
XFILLER_0_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4713_ regfile.registers\[24\]\[13\] regfile.registers\[25\]\[13\] regfile.registers\[26\]\[13\]
+ regfile.registers\[27\]\[13\] net1147 _1029_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__mux4_1
X_7501_ _3029_ net701 _3700_ VGND VGND VPWR VPWR _3704_ sky130_fd_sc_hd__mux2_1
XFILLER_0_127_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5693_ _1145_ _1166_ _2411_ VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__a21oi_1
X_8481_ net281 net23 _4216_ VGND VGND VPWR VPWR _4223_ sky130_fd_sc_hd__mux2_1
XFILLER_0_114_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4644_ regfile.registers\[20\]\[7\] regfile.registers\[21\]\[7\] regfile.registers\[22\]\[7\]
+ regfile.registers\[23\]\[7\] _1104_ _1105_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__mux4_1
X_7432_ _3667_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4575_ regfile.registers\[0\]\[31\] regfile.registers\[1\]\[31\] regfile.registers\[2\]\[31\]
+ regfile.registers\[3\]\[31\] _1324_ _1325_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold712 regfile.registers\[20\]\[19\] VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7363_ _3630_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold701 regfile.registers\[6\]\[11\] VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold745 regfile.registers\[15\]\[21\] VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlygate4sd3_1
Xhold734 regfile.registers\[13\]\[29\] VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlygate4sd3_1
X_9102_ clknet_leaf_5_CLK _0262_ VGND VGND VPWR VPWR regfile.registers\[27\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_7294_ _3027_ net1032 _3591_ VGND VGND VPWR VPWR _3594_ sky130_fd_sc_hd__mux2_1
X_6314_ net41 VGND VGND VPWR VPWR _3029_ sky130_fd_sc_hd__clkbuf_2
Xhold723 regfile.registers\[1\]\[6\] VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_110_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold778 regfile.registers\[28\]\[29\] VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlygate4sd3_1
X_6245_ _2675_ _2703_ _1803_ VGND VGND VPWR VPWR _2971_ sky130_fd_sc_hd__mux2_1
Xhold767 regfile.registers\[13\]\[9\] VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9033_ clknet_leaf_103_CLK _0193_ VGND VGND VPWR VPWR regfile.registers\[31\]\[11\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold756 regfile.registers\[13\]\[5\] VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dlygate4sd3_1
Xhold789 regfile.registers\[14\]\[14\] VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dlygate4sd3_1
X_6176_ _2904_ _2905_ VGND VGND VPWR VPWR _2906_ sky130_fd_sc_hd__xnor2_1
X_5127_ _1723_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_90_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5058_ _1812_ _1813_ _1713_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8817_ clknet_leaf_6_CLK _1001_ VGND VGND VPWR VPWR regfile.registers\[6\]\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8748_ clknet_leaf_0_CLK _0932_ VGND VGND VPWR VPWR regfile.registers\[8\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_8679_ clknet_leaf_56_CLK _0863_ VGND VGND VPWR VPWR regfile.registers\[0\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_23_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold50 regfile.registers\[17\]\[25\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 regfile.registers\[24\]\[1\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold83 regfile.registers\[1\]\[1\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 regfile.registers\[5\]\[12\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold94 regfile.registers\[10\]\[7\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_3 _1858_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_117_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4360_ _1112_ _1113_ _1114_ _1115_ _1047_ _1050_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__mux4_2
XFILLER_0_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4291_ net6 VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__buf_4
X_6030_ _1634_ _2767_ VGND VGND VPWR VPWR _2768_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer26 net1146 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer15 net1139 VGND VGND VPWR VPWR net1140 sky130_fd_sc_hd__dlygate4sd1_1
X_7981_ _3103_ net496 _3952_ VGND VGND VPWR VPWR _3958_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer37 _2724_ VGND VGND VPWR VPWR net1146 sky130_fd_sc_hd__dlymetal6s4s_1
X_6932_ _3385_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6863_ net198 _3109_ _3340_ VGND VGND VPWR VPWR _3349_ sky130_fd_sc_hd__mux2_1
XFILLER_0_119_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8602_ clknet_leaf_23_CLK _0786_ VGND VGND VPWR VPWR regfile.registers\[23\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_5814_ _2539_ _2543_ _2562_ VGND VGND VPWR VPWR _2563_ sky130_fd_sc_hd__o21ai_1
X_9582_ clknet_leaf_20_CLK _0742_ VGND VGND VPWR VPWR regfile.registers\[10\]\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_6794_ _3039_ net315 _3303_ VGND VGND VPWR VPWR _3312_ sky130_fd_sc_hd__mux2_1
XFILLER_0_123_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5745_ _2327_ _1169_ _1661_ VGND VGND VPWR VPWR _2497_ sky130_fd_sc_hd__and3_1
X_8533_ net305 net47 _4244_ VGND VGND VPWR VPWR _4250_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5676_ _2428_ _2429_ VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8464_ net149 net46 _4205_ VGND VGND VPWR VPWR _4214_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_20_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7415_ _3657_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
X_4627_ _1254_ _1382_ _1239_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_79_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold520 regfile.registers\[3\]\[3\] VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__dlygate4sd3_1
X_8395_ _4177_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__clkbuf_1
X_7346_ _3079_ net560 _3613_ VGND VGND VPWR VPWR _3621_ sky130_fd_sc_hd__mux2_1
XFILLER_0_114_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4558_ _1214_ _1313_ _1239_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__o21ai_1
Xhold542 regfile.registers\[23\]\[20\] VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold531 regfile.registers\[8\]\[18\] VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__dlygate4sd3_1
Xhold553 regfile.registers\[25\]\[13\] VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__dlygate4sd3_1
Xhold564 regfile.registers\[22\]\[25\] VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__dlygate4sd3_1
Xhold586 regfile.registers\[13\]\[25\] VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dlygate4sd3_1
X_7277_ _3583_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
X_4489_ _1243_ _1244_ _1211_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__mux2_1
Xhold575 regfile.registers\[9\]\[30\] VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold597 regfile.registers\[0\]\[17\] VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlygate4sd3_1
X_6228_ _2953_ _2954_ VGND VGND VPWR VPWR _2955_ sky130_fd_sc_hd__or2_4
X_9016_ clknet_leaf_21_CLK _0176_ VGND VGND VPWR VPWR regfile.registers\[29\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_6159_ _2015_ _2889_ VGND VGND VPWR VPWR _2890_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput51 net51 VGND VGND VPWR VPWR ALUResult[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_120_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput73 net73 VGND VGND VPWR VPWR ALUResult[31] sky130_fd_sc_hd__clkbuf_4
Xoutput62 net62 VGND VGND VPWR VPWR ALUResult[21] sky130_fd_sc_hd__buf_2
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5530_ _1670_ _2277_ _2281_ _2285_ VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5461_ regfile.registers\[28\]\[8\] regfile.registers\[29\]\[8\] regfile.registers\[30\]\[8\]
+ regfile.registers\[31\]\[8\] _2051_ _2053_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7200_ net32 VGND VGND VPWR VPWR _3542_ sky130_fd_sc_hd__buf_2
X_4412_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__buf_2
XFILLER_0_112_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5392_ regfile.registers\[28\]\[13\] regfile.registers\[29\]\[13\] regfile.registers\[30\]\[13\]
+ regfile.registers\[31\]\[13\] _1673_ _1690_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8180_ net242 _3496_ _4061_ VGND VGND VPWR VPWR _4064_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4343_ regfile.registers\[8\]\[3\] regfile.registers\[9\]\[3\] regfile.registers\[10\]\[3\]
+ regfile.registers\[11\]\[3\] net96 _1044_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__mux4_1
X_7131_ _3495_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_74_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4274_ regfile.registers\[20\]\[4\] regfile.registers\[21\]\[4\] regfile.registers\[22\]\[4\]
+ regfile.registers\[23\]\[4\] _1027_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__mux4_1
X_7062_ net832 _3103_ _3449_ VGND VGND VPWR VPWR _3455_ sky130_fd_sc_hd__mux2_1
X_6013_ _2341_ _2401_ VGND VGND VPWR VPWR _2752_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_129_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7964_ _3948_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__clkbuf_1
X_6915_ net195 _3089_ _3376_ VGND VGND VPWR VPWR _3377_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7895_ net482 _3484_ _3902_ VGND VGND VPWR VPWR _3912_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6846_ _3339_ VGND VGND VPWR VPWR _3340_ sky130_fd_sc_hd__buf_4
XFILLER_0_49_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9565_ clknet_leaf_14_CLK _0725_ VGND VGND VPWR VPWR regfile.registers\[11\]\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_6777_ _3302_ VGND VGND VPWR VPWR _3303_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5728_ _2062_ _2479_ VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__nand2_1
X_8516_ net417 net27 _3007_ VGND VGND VPWR VPWR _4241_ sky130_fd_sc_hd__mux2_1
X_9496_ clknet_leaf_17_CLK _0656_ VGND VGND VPWR VPWR regfile.registers\[16\]\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5659_ _2097_ _2410_ _2412_ VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__and3_1
X_8447_ _4204_ VGND VGND VPWR VPWR _4205_ sky130_fd_sc_hd__clkbuf_8
X_8378_ _3192_ _3229_ VGND VGND VPWR VPWR _4168_ sky130_fd_sc_hd__nor2b_4
X_7329_ _3062_ net840 _3602_ VGND VGND VPWR VPWR _3612_ sky130_fd_sc_hd__mux2_1
Xhold361 regfile.registers\[7\]\[16\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__dlygate4sd3_1
Xhold350 regfile.registers\[3\]\[2\] VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlygate4sd3_1
Xhold383 regfile.registers\[4\]\[11\] VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__dlygate4sd3_1
Xhold372 regfile.registers\[4\]\[1\] VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__dlygate4sd3_1
Xhold394 regfile.registers\[20\]\[15\] VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1050 regfile.registers\[15\]\[28\] VGND VGND VPWR VPWR net1130 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_100_CLK clknet_3_4__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_100_CLK
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_67_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer6 _2657_ VGND VGND VPWR VPWR net1137 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_114_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_125_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4961_ _1716_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__clkbuf_8
X_7680_ _3798_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
X_6700_ _3081_ net1130 _3253_ VGND VGND VPWR VPWR _3262_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4892_ regfile.registers\[24\]\[0\] regfile.registers\[25\]\[0\] regfile.registers\[26\]\[0\]
+ regfile.registers\[27\]\[0\] net1 net2 VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__mux4_1
XFILLER_0_117_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6631_ net320 _3011_ _3216_ VGND VGND VPWR VPWR _3225_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9350_ clknet_leaf_55_CLK _0510_ VGND VGND VPWR VPWR regfile.registers\[20\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_703 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6562_ _3083_ net897 _3177_ VGND VGND VPWR VPWR _3187_ sky130_fd_sc_hd__mux2_1
X_8301_ _4127_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_736 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6493_ net545 _3013_ _3135_ VGND VGND VPWR VPWR _3150_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9281_ clknet_leaf_85_CLK _0441_ VGND VGND VPWR VPWR regfile.registers\[25\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5513_ _2267_ _2268_ _1738_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8232_ net117 _3480_ _4083_ VGND VGND VPWR VPWR _4091_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5444_ _2198_ _2199_ _2044_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__mux2_1
X_8163_ _4054_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__clkbuf_1
X_7114_ _3483_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5375_ _2127_ _2130_ _1696_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__mux2_1
X_8094_ net661 _3478_ _4011_ VGND VGND VPWR VPWR _4018_ sky130_fd_sc_hd__mux2_1
X_4326_ _1078_ _1081_ _1057_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__a21oi_1
X_7045_ net714 _3015_ _3411_ VGND VGND VPWR VPWR _3445_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8996_ clknet_leaf_91_CLK _0156_ VGND VGND VPWR VPWR regfile.registers\[29\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_7947_ _3137_ net796 _3938_ VGND VGND VPWR VPWR _3940_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7878_ _3903_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6829_ _3330_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9548_ clknet_leaf_110_CLK _0708_ VGND VGND VPWR VPWR regfile.registers\[11\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_9479_ clknet_leaf_63_CLK _0639_ VGND VGND VPWR VPWR regfile.registers\[16\]\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold180 regfile.registers\[2\]\[25\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold191 regfile.registers\[21\]\[27\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_639 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5160_ _1773_ _1915_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_71_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5091_ regfile.registers\[24\]\[17\] regfile.registers\[25\]\[17\] regfile.registers\[26\]\[17\]
+ regfile.registers\[27\]\[17\] _1689_ _1693_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__mux4_1
XFILLER_0_78_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8850_ clknet_leaf_60_CLK _0010_ VGND VGND VPWR VPWR regfile.registers\[5\]\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_5993_ _2327_ _2675_ _2732_ VGND VGND VPWR VPWR _2733_ sky130_fd_sc_hd__a21o_1
X_7801_ _3862_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__clkbuf_1
X_8781_ clknet_leaf_97_CLK _0965_ VGND VGND VPWR VPWR regfile.registers\[14\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4944_ _1699_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__buf_4
XFILLER_0_91_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7732_ _3056_ net866 _3819_ VGND VGND VPWR VPWR _3826_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9402_ clknet_leaf_31_CLK _0562_ VGND VGND VPWR VPWR regfile.registers\[24\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4875_ regfile.registers\[0\]\[18\] regfile.registers\[1\]\[18\] regfile.registers\[2\]\[18\]
+ regfile.registers\[3\]\[18\] _1173_ _1175_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_15_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7663_ _3789_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6614_ _3193_ VGND VGND VPWR VPWR _3216_ sky130_fd_sc_hd__clkbuf_8
X_7594_ _3054_ net686 _3747_ VGND VGND VPWR VPWR _3753_ sky130_fd_sc_hd__mux2_1
X_9333_ clknet_leaf_29_CLK _0493_ VGND VGND VPWR VPWR regfile.registers\[21\]\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_6545_ _3178_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9264_ clknet_leaf_9_CLK _0424_ VGND VGND VPWR VPWR regfile.registers\[18\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_112_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6476_ net433 _3139_ _3135_ VGND VGND VPWR VPWR _3140_ sky130_fd_sc_hd__mux2_1
X_8215_ net416 _3531_ _4072_ VGND VGND VPWR VPWR _4082_ sky130_fd_sc_hd__mux2_1
X_9195_ clknet_leaf_104_CLK _0355_ VGND VGND VPWR VPWR regfile.registers\[30\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5427_ regfile.registers\[20\]\[11\] regfile.registers\[21\]\[11\] regfile.registers\[22\]\[11\]
+ regfile.registers\[23\]\[11\] _1675_ _1692_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__mux4_1
X_5358_ _2052_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__buf_4
X_8146_ _4045_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__clkbuf_1
X_4309_ A2[0] VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__buf_12
X_8077_ net998 _3529_ _4000_ VGND VGND VPWR VPWR _4009_ sky130_fd_sc_hd__mux2_1
X_7028_ _3436_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_5289_ _2042_ _2043_ _2044_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8979_ clknet_leaf_30_CLK _0139_ VGND VGND VPWR VPWR regfile.registers\[7\]\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_122_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4660_ _1399_ _1415_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__nand2_4
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4591_ _1341_ _1343_ _1346_ _1187_ _1215_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__o221a_4
X_6330_ _3039_ net679 _3023_ VGND VGND VPWR VPWR _3040_ sky130_fd_sc_hd__mux2_1
Xhold916 regfile.registers\[15\]\[25\] VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__dlygate4sd3_1
Xhold927 regfile.registers\[26\]\[28\] VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__dlygate4sd3_1
Xhold905 regfile.registers\[30\]\[10\] VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__dlygate4sd3_1
Xhold938 regfile.registers\[26\]\[24\] VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__dlygate4sd3_1
X_6261_ _2934_ _2940_ _2951_ _2932_ VGND VGND VPWR VPWR _2987_ sky130_fd_sc_hd__a211o_1
Xhold949 regfile.registers\[3\]\[13\] VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__dlygate4sd3_1
X_6192_ _2918_ _2920_ VGND VGND VPWR VPWR _2921_ sky130_fd_sc_hd__xor2_1
X_5212_ _1966_ _1967_ _1745_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8000_ _3122_ net368 _3963_ VGND VGND VPWR VPWR _3968_ sky130_fd_sc_hd__mux2_1
X_5143_ regfile.registers\[4\]\[31\] regfile.registers\[5\]\[31\] regfile.registers\[6\]\[31\]
+ regfile.registers\[7\]\[31\] _1896_ _1898_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__mux4_1
X_5074_ regfile.registers\[12\]\[19\] regfile.registers\[13\]\[19\] regfile.registers\[14\]\[19\]
+ regfile.registers\[15\]\[19\] _1689_ _1693_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__mux4_1
X_8902_ clknet_leaf_69_CLK _0062_ VGND VGND VPWR VPWR regfile.registers\[19\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_126_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8833_ clknet_leaf_90_CLK _1017_ VGND VGND VPWR VPWR regfile.registers\[5\]\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5976_ _2344_ _2342_ VGND VGND VPWR VPWR _2717_ sky130_fd_sc_hd__and2_1
X_8764_ clknet_leaf_13_CLK _0948_ VGND VGND VPWR VPWR regfile.registers\[8\]\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_4927_ regfile.registers\[16\]\[23\] regfile.registers\[17\]\[23\] regfile.registers\[18\]\[23\]
+ regfile.registers\[19\]\[23\] _1676_ _1681_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__mux4_1
X_8695_ clknet_leaf_50_CLK _0879_ VGND VGND VPWR VPWR regfile.registers\[0\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7715_ _3039_ net596 _3808_ VGND VGND VPWR VPWR _3817_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4858_ regfile.registers\[8\]\[19\] regfile.registers\[9\]\[19\] regfile.registers\[10\]\[19\]
+ regfile.registers\[11\]\[19\] _1173_ _1175_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__mux4_1
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7646_ _3780_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_10_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7577_ _3037_ net589 _3736_ VGND VGND VPWR VPWR _3744_ sky130_fd_sc_hd__mux2_1
X_4789_ _1543_ _1544_ _1034_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__mux2_1
X_9316_ clknet_leaf_92_CLK _0476_ VGND VGND VPWR VPWR regfile.registers\[21\]\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_6528_ _3169_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_80_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_80_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_95_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9247_ clknet_leaf_81_CLK _0407_ VGND VGND VPWR VPWR regfile.registers\[18\]\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6459_ net24 VGND VGND VPWR VPWR _3128_ sky130_fd_sc_hd__buf_2
X_9178_ clknet_leaf_16_CLK _0338_ VGND VGND VPWR VPWR regfile.registers\[2\]\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8129_ net279 _3512_ _4036_ VGND VGND VPWR VPWR _4037_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_104_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_71_CLK clknet_3_5__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_71_CLK sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_55_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5830_ _2577_ _2498_ _1803_ VGND VGND VPWR VPWR _2578_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5761_ _2511_ _2512_ VGND VGND VPWR VPWR _2513_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_45_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4712_ regfile.registers\[28\]\[13\] regfile.registers\[29\]\[13\] regfile.registers\[30\]\[13\]
+ regfile.registers\[31\]\[13\] net1147 _1029_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__mux4_1
X_7500_ _3703_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
X_8480_ _4222_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_127_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5692_ _1666_ _2445_ VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__nor2_1
X_7431_ _3027_ net1113 _3664_ VGND VGND VPWR VPWR _3667_ sky130_fd_sc_hd__mux2_1
XFILLER_0_126_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4643_ _1390_ _1025_ _1398_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4574_ regfile.registers\[4\]\[31\] regfile.registers\[5\]\[31\] regfile.registers\[6\]\[31\]
+ regfile.registers\[7\]\[31\] _1324_ _1325_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_62_CLK clknet_3_7__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_62_CLK sky130_fd_sc_hd__clkbuf_8
X_7362_ _3027_ net978 _3627_ VGND VGND VPWR VPWR _3630_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold702 regfile.registers\[21\]\[17\] VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlygate4sd3_1
Xhold713 regfile.registers\[27\]\[24\] VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlygate4sd3_1
X_7293_ _3593_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
Xhold724 regfile.registers\[29\]\[13\] VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlygate4sd3_1
Xhold735 regfile.registers\[16\]\[12\] VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlygate4sd3_1
X_6313_ _3028_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9101_ clknet_leaf_11_CLK _0261_ VGND VGND VPWR VPWR regfile.registers\[27\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold746 regfile.registers\[26\]\[16\] VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6244_ _2672_ _2674_ _1803_ VGND VGND VPWR VPWR _2970_ sky130_fd_sc_hd__mux2_1
Xhold768 regfile.registers\[26\]\[3\] VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlygate4sd3_1
X_9032_ clknet_leaf_102_CLK _0192_ VGND VGND VPWR VPWR regfile.registers\[31\]\[10\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold757 regfile.registers\[9\]\[2\] VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlygate4sd3_1
Xhold779 regfile.registers\[26\]\[17\] VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlygate4sd3_1
X_6175_ _2887_ _2890_ _2892_ VGND VGND VPWR VPWR _2905_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5126_ _1881_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__buf_4
X_5057_ regfile.registers\[12\]\[18\] regfile.registers\[13\]\[18\] regfile.registers\[14\]\[18\]
+ regfile.registers\[15\]\[18\] _1689_ _1693_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__mux4_1
X_8816_ clknet_leaf_10_CLK _1000_ VGND VGND VPWR VPWR regfile.registers\[6\]\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_5959_ _2335_ _2701_ VGND VGND VPWR VPWR _2702_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8747_ clknet_leaf_106_CLK _0931_ VGND VGND VPWR VPWR regfile.registers\[8\]\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8678_ clknet_leaf_55_CLK _0862_ VGND VGND VPWR VPWR regfile.registers\[0\]\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_23_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7629_ _3005_ _3190_ VGND VGND VPWR VPWR _3771_ sky130_fd_sc_hd__nor2_2
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_53_CLK clknet_3_6__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_53_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_50_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold40 regfile.registers\[17\]\[12\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 regfile.registers\[18\]\[27\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 regfile.registers\[7\]\[20\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 regfile.registers\[5\]\[7\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold95 regfile.registers\[0\]\[19\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 regfile.registers\[2\]\[0\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_106_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_44_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_44_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_124_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_4 _1923_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4290_ _1040_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer27 _2745_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd1_1
X_7980_ _3957_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6931_ net150 _3109_ _3376_ VGND VGND VPWR VPWR _3385_ sky130_fd_sc_hd__mux2_1
X_6862_ _3348_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8601_ clknet_leaf_37_CLK _0785_ VGND VGND VPWR VPWR regfile.registers\[23\]\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_5813_ _2271_ _2538_ VGND VGND VPWR VPWR _2562_ sky130_fd_sc_hd__or2_1
X_9581_ clknet_leaf_95_CLK _0741_ VGND VGND VPWR VPWR regfile.registers\[10\]\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8532_ _4249_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6793_ _3311_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__clkbuf_1
X_5744_ _2495_ VGND VGND VPWR VPWR _2496_ sky130_fd_sc_hd__buf_2
X_5675_ _1800_ _2247_ VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__nor2_1
X_8463_ _4213_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_20_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_35_CLK clknet_3_3__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_35_CLK sky130_fd_sc_hd__clkbuf_8
X_7414_ _3079_ net419 _3649_ VGND VGND VPWR VPWR _3657_ sky130_fd_sc_hd__mux2_1
X_4626_ _1380_ _1381_ _1190_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8394_ net788 _3506_ _4169_ VGND VGND VPWR VPWR _4177_ sky130_fd_sc_hd__mux2_1
X_7345_ _3620_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
Xhold510 regfile.registers\[24\]\[12\] VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__dlygate4sd3_1
X_4557_ _1311_ _1312_ _1199_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_92_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold554 regfile.registers\[16\]\[9\] VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__dlygate4sd3_1
Xhold543 regfile.registers\[20\]\[5\] VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold521 regfile.registers\[31\]\[17\] VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold532 regfile.registers\[16\]\[7\] VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__dlygate4sd3_1
X_7276_ net295 _3480_ _3575_ VGND VGND VPWR VPWR _3583_ sky130_fd_sc_hd__mux2_1
Xhold565 regfile.registers\[7\]\[23\] VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__dlygate4sd3_1
X_4488_ regfile.registers\[24\]\[20\] regfile.registers\[25\]\[20\] regfile.registers\[26\]\[20\]
+ regfile.registers\[27\]\[20\] _1207_ _1208_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__mux4_1
Xhold576 regfile.registers\[4\]\[10\] VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__dlygate4sd3_1
Xhold587 regfile.registers\[2\]\[4\] VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlygate4sd3_1
X_9015_ clknet_leaf_34_CLK _0175_ VGND VGND VPWR VPWR regfile.registers\[29\]\[25\]
+ sky130_fd_sc_hd__dfxtp_1
Xhold598 regfile.registers\[23\]\[25\] VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__dlygate4sd3_1
X_6227_ _2934_ _2940_ _2932_ VGND VGND VPWR VPWR _2954_ sky130_fd_sc_hd__a21oi_2
X_6158_ _1370_ _2888_ VGND VGND VPWR VPWR _2889_ sky130_fd_sc_hd__xor2_1
X_5109_ _1861_ _1862_ _1863_ _1864_ _1713_ _1717_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__mux4_2
X_6089_ _2756_ _2751_ _2426_ VGND VGND VPWR VPWR _2824_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_26_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_26_CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_0_23_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput52 net52 VGND VGND VPWR VPWR ALUResult[12] sky130_fd_sc_hd__buf_6
Xoutput63 net63 VGND VGND VPWR VPWR ALUResult[22] sky130_fd_sc_hd__clkbuf_4
Xoutput74 net74 VGND VGND VPWR VPWR ALUResult[3] sky130_fd_sc_hd__buf_2
XFILLER_0_128_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_17_CLK clknet_3_2__leaf_CLK VGND VGND VPWR VPWR clknet_leaf_17_CLK sky130_fd_sc_hd__clkbuf_8
X_5460_ _2214_ _2215_ _1685_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4411_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__buf_2
XFILLER_0_111_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5391_ _2145_ _2146_ _1684_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4342_ _1038_ _1097_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__nand2_2
XFILLER_0_22_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7130_ net248 _3494_ _3492_ VGND VGND VPWR VPWR _3495_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_74_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7061_ _3454_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_4273_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__buf_4
X_6012_ _2649_ _2697_ _2327_ VGND VGND VPWR VPWR _2751_ sky130_fd_sc_hd__mux2_1
.ends
